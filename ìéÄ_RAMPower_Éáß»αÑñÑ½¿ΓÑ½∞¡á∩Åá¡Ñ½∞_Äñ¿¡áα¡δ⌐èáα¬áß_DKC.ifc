Properties of the parts of a building model (IFC2X3), part 1 of 4

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2022-10-07T01:42:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181217_1515(x64) - Exporter 19.2.0.65 - Альтернативный интерфейс 19.2.0.65
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Oct 07 01:42:53 2022 * Host: SERGEY_MIKHALEV * Database: C:\Users\mkhlv\AppData\Local\Temp\{AEF2F5DB-F89A-4028-8023-96151017320E}\ifc * Database version: 5507 * Database creation date: Fri Oct 07 01:42:51 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Oct 07 01:42:51 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Oct 07 01:42:51 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2022
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2022
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее(Type) - Категория: Уровни; Имя семейства: Уровень
Идентификация(Type) - Имя типа: Отметка уровня с именем
Зависимости(Type) - Базовая отметка: Базовая точка проекта
Графика(Type) - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Зависимости - Фасад: 0 mm
Идентификация - Вариант конструкции: Главная модель; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Прочее - Категория: Уровни; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Размеры - Расчетная высота: 0 mm

# IfcBuildingElementProxy: 2000 х 1000 х 600 (max 2500А, одностороннее обслуживание), НВО_RAMPower_РаспределительнаяПанель_ОдинарныйКаркас_DKC:2000 х 1000 х 600 (max 2500А, одностороннее обслуживание):696278
In: Этаж 01
Type - Material: DKC_Красный_Лого, DKC_Металл_Светлый, DKC_Металл_Серый, DKC_Зона обслуживания
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Распределительная панель, одинарный каркас, 2000 х 1000 х 600 (max 2500А, одностороннее обслуживание); ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2; DKC_Ударопрочность: IK10
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: 2000 х 1000 х 600 (max 2500А, одностороннее обслуживание); Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 01_Название колонны_A: A - Панель для воздушных выключателей; 01_Название колонны_C: С - Панель комбинированная; 01_Название колонны_M: M - Панель управления электродвигателями; 02_Номинальный ток горизонтальных сборных шин панели_00: 00 - без сборных шин; 02_Номинальный ток горизонтальных сборных шин панели_06: 06 = 630 А; 02_Номинальный ток горизонтальных сборных шин панели_08: 08 = 800 А; 02_Номинальный ток горизонтальных сборных шин панели_10: 10 = 1000 А; 02_Номинальный ток горизонтальных сборных шин панели_12: 12 = 1250 А; 02_Номинальный ток горизонтальных сборных шин панели_16: 16 = 1600 А; 02_Номинальный ток горизонтальных сборных шин панели_20: 20 = 2000 А; 02_Номинальный ток горизонтальных сборных шин панели_25: 25 = 2500 А; 02_Номинальный ток горизонтальных сборных шин панели_32: 32 = 3200 А; 02_Номинальный ток горизонтальных сборных шин панели_40: 40 = 4000 А; 02_Номинальный ток горизонтальных сборных шин панели_50: 50 = 5000 А; 02_Номинальный ток горизонтальных сборных шин панели_63: 63 = 6300 А; 03_Номинальный ток вертикальных шин_00: 00 - без сборных шин; 03_Номинальный ток вертикальных шин_06: 06 = 630 А; 03_Номинальный ток вертикальных шин_08: 08 = 800 А; 03_Номинальный ток вертикальных шин_10: 10 = 1000 А; 03_Номинальный ток вертикальных шин_12: 12 = 1250 А; 03_Номинальный ток вертикальных шин_16: 16 = 1600 А; 03_Номинальный ток вертикальных шин_20: 20 = 2000 А; 03_Номинальный ток вертикальных шин_25: 25 = 2500 А; 03_Номинальный ток вертикальных шин_32: 32 = 3200 А; 03_Номинальный ток вертикальных шин_40: 40 = 4000 А; 03_Номинальный ток вертикальных шин_50: 50 = 5000 А; 03_Номинальный ток вертикальных шин_63: 63 = 6300 А; 04_Ток КЗ шинной системы_A: A= 25; 04_Ток КЗ шинной системы_B: B = 36; 04_Ток КЗ шинной системы_C: C = 50; 04_Ток КЗ шинной системы_D: D = 65; 04_Ток КЗ шинной системы_E: E = 75; 04_Ток КЗ шинной системы_F: F = 85; 04_Ток КЗ шинной системы_G: G = 100; 05_Система заземления_C: C = TN-C; 05_Система заземления_D: D = TN-C-S; 05_Система заземления_I: I = IT; 05_Система заземления_S: S = TN-S; 05_Система заземления_T: T = TT; 06_Количество распределительных шин_3: 3 – полюса; 06_Количество распределительных шин_4: 4 – полюса; 07_Подключение_A: A - верхнее шинопроводом; 07_Подключение_B: B - верхнее кабелем; 07_Подключение_C: C - нижнее кабелем; 07_Подключение_D: D - боковое левое шинами; 07_Подключение_E: E - боковое правое шинами; 07_Подключение_Х: Х - без внешних силовых подключений; 08_Обслуживание_IP31: 1/2 - IP31; 08_Обслуживание_IP54: 3/4 - IP54; 09_Высота панели_Без цоколя: Без цоколя; 09_Высота панели_С цоколем: С цоколем; 11_Ширина кабельной колонны (при одностороннем обслуж)_0: 0 - отсутствует; 11_Ширина кабельной колонны (при одностороннем обслуж)_4 слева: 4 - 400 слева; 11_Ширина кабельной колонны (при одностороннем обслуж)_4 справа: 4 - 400 справа; 11_Ширина кабельной колонны (при одностороннем обслуж)_6 слева: 6 - 600 слева; 11_Ширина кабельной колонны (при одностороннем обслуж)_6 справа: 6 - 600 справа; 12_Секционирование_1a: 1a - без секционирования; 12_Секционирование_2a: 2a - секционирование; 12_Секционирование_2b: 2b - секционирование; 12_Секционирование_3a: 3a - секционирование; 12_Секционирование_3b: 3b - секционирование; 12_Секционирование_4a: 4a - секционирование; 12_Секционирование_4b: 4b - секционирование; Обслуживание: 1; Имя семейства: НВО_RAMPower_РаспределительнаяПанель_ОдинарныйКаркас_DKC
Type - Размеры - ADSK_Размер_Высота: 2000 mm; ADSK_Размер_Глубина: 600 mm; ADSK_Размер_Ширина: 1000 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: 2000 х 1000 х 600 (max 2500А, одностороннее обслуживание)
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 01_Название колонны: С - Панель комбинированная; 02_Номинальный ток горизонтальных сборных шин панели: 32 = 3200 А; 03_Номинальный ток вертикальных шин: 32 = 3200 А; 04_Ток КЗ шинной системы: G = 100; 05_Система заземления: S = TN-S; 06_Количество распределительных шин: 3 – полюса; 07_Подключение: B - верхнее кабелем; 08_Обслуживание: 3/4 - IP54; 09_Высота панели: С цоколем; 11_Ширина кабельной колонны (при одностороннем обслуж): 0 - отсутствует; 12_Секционирование: 3b - секционирование
Зависимости - Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Марка: 65
Прочее - IP31: no; Боковые стенки_Видимость: yes; Задняя стенка_Видимость: yes; Зона обслуживания_Видимость: yes; Зона обслуживания сзади_Видимость: no; Кабельная колонна слева: no; Кабельная колонна справа: no; Комлект ввода_Видимость: no; Ручка_Видимость: no; Цоколь_Видимость: yes; Код типа: НВО_RAMPower_РаспределительнаяПанель_ОдинарныйКаркас_DKC: 2000 х 1000 х 600 (max 2500А, одностороннее обслуживание); Семейство: НВО_RAMPower_РаспределительнаяПанель_ОдинарныйКаркас_DKC: 2000 х 1000 х 600 (max 2500А, одностороннее обслуживание); Семейство и типоразмер: НВО_RAMPower_РаспределительнаяПанель_ОдинарныйКаркас_DKC: 2000 х 1000 х 600 (max 2500А, одностороннее обслуживание); Тип: НВО_RAMPower_РаспределительнаяПанель_ОдинарныйКаркас_DKC: 2000 х 1000 х 600 (max 2500А, одностороннее обслуживание)
Размеры - Высота 2200: 0 mm; Комплект ввода_Высота: 0 mm; Высота стенок: 1950 mm; Объем: 6.384 m3; Площадь: 40.0333 m2; Цоколь: 100 mm; Ширина кабельной колонны: 600 mm; Ширина стенок: 560 mm
Стадии - Стадия возведения: Стадия 1
Строительство - Боковые стенки: yes; Вспомогательная надпись: yes; Задняя стенка: yes; Закрытие свободного пространства: 0; Зона обслуживания: yes; Режим установки оборудования: no; Стойки: yes
Текст - DKC_Артикул_01_Название колонны: C; DKC_Артикул_02_Номинальный ток горизонтальных сборных шин панели: 32; DKC_Артикул_03_Номинальный ток вертикальных шин: 32; DKC_Артикул_04_Ток КЗ шинной системы: G; DKC_Артикул_05_Система заземления: S; DKC_Артикул_06_Количество распределительных шин: 3; DKC_Артикул_07_Подключение: B; DKC_Артикул_08_Обслуживание: 3; DKC_Артикул_09_Высота панели: Y; DKC_Артикул_10_Ширина и глубина основной колонны: 16; DKC_Артикул_11_Ширина кабельной колонны (при одностороннем обслуж): 0; DKC_Артикул_12_Секционирование: 3b
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: 2000 х 1000 х 800 (max 4000А, двухстороннее обслуживание), НВО_RAMPower_РаспределительнаяПанель_ОдинарныйКаркас_DKC:2000 х 1000 х 800 (max 4000А, двухстороннее обслуживание):696281
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Красный_Лого, DKC_Металл_Светлый, DKC_Зона обслуживания
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Распределительная панель, одинарный каркас, 2000 х 1000 х 800 (max 4000А, двухстороннее обслуживание); ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2; DKC_Ударопрочность: IK10
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: 2000 х 1000 х 800 (max 4000А, двухстороннее обслуживание); Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 01_Название колонны_A: A - Панель для воздушных выключателей; 01_Название колонны_C: С - Панель комбинированная; 01_Название колонны_M: M - Панель управления электродвигателями; 02_Номинальный ток горизонтальных сборных шин панели_00: 00 - без сборных шин; 02_Номинальный ток горизонтальных сборных шин панели_06: 06 = 630 А; 02_Номинальный ток горизонтальных сборных шин панели_08: 08 = 800 А; 02_Номинальный ток горизонтальных сборных шин панели_10: 10 = 1000 А; 02_Номинальный ток горизонтальных сборных шин панели_12: 12 = 1250 А; 02_Номинальный ток горизонтальных сборных шин панели_16: 16 = 1600 А; 02_Номинальный ток горизонтальных сборных шин панели_20: 20 = 2000 А; 02_Номинальный ток горизонтальных сборных шин панели_25: 25 = 2500 А; 02_Номинальный ток горизонтальных сборных шин панели_32: 32 = 3200 А; 02_Номинальный ток горизонтальных сборных шин панели_40: 40 = 4000 А; 02_Номинальный ток горизонтальных сборных шин панели_50: 50 = 5000 А; 02_Номинальный ток горизонтальных сборных шин панели_63: 63 = 6300 А; 03_Номинальный ток вертикальных шин_00: 00 - без сборных шин; 03_Номинальный ток вертикальных шин_06: 06 = 630 А; 03_Номинальный ток вертикальных шин_08: 08 = 800 А; 03_Номинальный ток вертикальных шин_10: 10 = 1000 А; 03_Номинальный ток вертикальных шин_12: 12 = 1250 А; 03_Номинальный ток вертикальных шин_16: 16 = 1600 А; 03_Номинальный ток вертикальных шин_20: 20 = 2000 А; 03_Номинальный ток вертикальных шин_25: 25 = 2500 А; 03_Номинальный ток вертикальных шин_32: 32 = 3200 А; 03_Номинальный ток вертикальных шин_40: 40 = 4000 А; 03_Номинальный ток вертикальных шин_50: 50 = 5000 А; 03_Номинальный ток вертикальных шин_63: 63 = 6300 А; 04_Ток КЗ шинной системы_A: A= 25; 04_Ток КЗ шинной системы_B: B = 36; 04_Ток КЗ шинной системы_C: C = 50; 04_Ток КЗ шинной системы_D: D = 65; 04_Ток КЗ шинной системы_E: E = 75; 04_Ток КЗ шинной системы_F: F = 85; 04_Ток КЗ шинной системы_G: G = 100; 05_Система заземления_C: C = TN-C; 05_Система заземления_D: D = TN-C-S; 05_Система заземления_I: I = IT; 05_Система заземления_S: S = TN-S; 05_Система заземления_T: T = TT; 06_Количество распределительных шин_3: 3 – полюса; 06_Количество распределительных шин_4: 4 – полюса; 07_Подключение_A: A - верхнее шинопроводом; 07_Подключение_B: B - верхнее кабелем; 07_Подключение_C: C - нижнее кабелем; 07_Подключение_D: D - боковое левое шинами; 07_Подключение_E: E - боковое правое шинами; 07_Подключение_Х: Х - без внешних силовых подключений; 08_Обслуживание_IP31: 1/2 - IP31; 08_Обслуживание_IP54: 3/4 - IP54; 09_Высота панели_Без цоколя: Без цоколя; 09_Высота панели_С цоколем: С цоколем; 11_Ширина кабельной колонны (при одностороннем обслуж)_0: 0 - отсутствует; 11_Ширина кабельной колонны (при одностороннем обслуж)_4 слева: 4 - 400 слева; 11_Ширина кабельной колонны (при одностороннем обслуж)_4 справа: 4 - 400 справа; 11_Ширина кабельной колонны (при одностороннем обслуж)_6 слева: 6 - 600 слева; 11_Ширина кабельной колонны (при одностороннем обслуж)_6 справа: 6 - 600 справа; 12_Секционирование_1a: 1a - без секционирования; 12_Секционирование_2a: 2a - секционирование; 12_Секционирование_2b: 2b - секционирование; 12_Секционирование_3a: 3a - секционирование; 12_Секционирование_3b: 3b - секционирование; 12_Секционирование_4a: 4a - секционирование; 12_Секционирование_4b: 4b - секционирование; Обслуживание: 2; Имя семейства: НВО_RAMPower_РаспределительнаяПанель_ОдинарныйКаркас_DKC
Type - Размеры - ADSK_Размер_Высота: 2000 mm; ADSK_Размер_Глубина: 800 mm; ADSK_Размер_Ширина: 1000 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: 2000 х 1000 х 800 (max 4000А, двухстороннее обслуживание)
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 01_Название колонны: С - Панель комбинированная; 02_Номинальный ток горизонтальных сборных шин панели: 32 = 3200 А; 03_Номинальный ток вертикальных шин: 32 = 3200 А; 04_Ток КЗ шинной системы: G = 100; 05_Система заземления: S = TN-S; 06_Количество распределительных шин: 3 – полюса; 07_Подключение: B - верхнее кабелем; 08_Обслуживание: 3/4 - IP54; 09_Высота панели: С цоколем; 11_Ширина кабельной колонны (при одностороннем обслуж): 0 - отсутствует; 12_Секционирование: 3b - секционирование
Зависимости - Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 67
Прочее - IP31: no; Боковые стенки_Видимость: yes; Задняя стенка_Видимость: yes; Зона обслуживания_Видимость: yes; Кабельная колонна слева: no; Кабельная колонна справа: no; Комлект ввода_Видимость: no; Цоколь_Видимость: yes; Зона обслуживания сзади_Видимость: yes; Ручка_Видимость: yes; Код типа: НВО_RAMPower_РаспределительнаяПанель_ОдинарныйКаркас_DKC: 2000 х 1000 х 800 (max 4000А, двухстороннее обслуживание); Семейство: НВО_RAMPower_РаспределительнаяПанель_ОдинарныйКаркас_DKC: 2000 х 1000 х 800 (max 4000А, двухстороннее обслуживание); Семейство и типоразмер: НВО_RAMPower_РаспределительнаяПанель_ОдинарныйКаркас_DKC: 2000 х 1000 х 800 (max 4000А, двухстороннее обслуживание); Тип: НВО_RAMPower_РаспределительнаяПанель_ОдинарныйКаркас_DKC: 2000 х 1000 х 800 (max 4000А, двухстороннее обслуживание)
Размеры - Высота 2200: 0 mm; Комплект ввода_Высота: 0 mm; Высота стенок: 1950 mm; Объем: 10.92 m3; Площадь: 43.3199 m2; Цоколь: 100 mm; Ширина кабельной колонны: 600 mm; Ширина стенок: 760 mm
Стадии - Стадия возведения: Стадия 1
Строительство - Боковые стенки: yes; Вспомогательная надпись: yes; Задняя стенка: yes; Закрытие свободного пространства: 0; Зона обслуживания: yes; Режим установки оборудования: no; Стойки: yes
Текст - DKC_Артикул_01_Название колонны: C; DKC_Артикул_02_Номинальный ток горизонтальных сборных шин панели: 32; DKC_Артикул_03_Номинальный ток вертикальных шин: 32; DKC_Артикул_04_Ток КЗ шинной системы: G; DKC_Артикул_05_Система заземления: S; DKC_Артикул_06_Количество распределительных шин: 3; DKC_Артикул_07_Подключение: B; DKC_Артикул_08_Обслуживание: 4; DKC_Артикул_09_Высота панели: Y; DKC_Артикул_10_Ширина и глубина основной колонны: 18; DKC_Артикул_11_Ширина кабельной колонны (при одностороннем обслуж): 0; DKC_Артикул_12_Секционирование: 3b
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: 2000 х 1000 х 800 (max 4000А, одностороннее обслуживание), НВО_RAMPower_РаспределительнаяПанель_ОдинарныйКаркас_DKC:2000 х 1000 х 800 (max 4000А, одностороннее обслуживание):696280
In: Этаж 01
Type - Material: DKC_Красный_Лого, DKC_Металл_Светлый, DKC_Металл_Серый, DKC_Зона обслуживания
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Распределительная панель, одинарный каркас, 2000 х 1000 х 800 (max 4000А, одностороннее обслуживание); ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2; DKC_Ударопрочность: IK10
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: 2000 х 1000 х 800 (max 4000А, одностороннее обслуживание); Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 01_Название колонны_A: A - Панель для воздушных выключателей; 01_Название колонны_C: С - Панель комбинированная; 01_Название колонны_M: M - Панель управления электродвигателями; 02_Номинальный ток горизонтальных сборных шин панели_00: 00 - без сборных шин; 02_Номинальный ток горизонтальных сборных шин панели_06: 06 = 630 А; 02_Номинальный ток горизонтальных сборных шин панели_08: 08 = 800 А; 02_Номинальный ток горизонтальных сборных шин панели_10: 10 = 1000 А; 02_Номинальный ток горизонтальных сборных шин панели_12: 12 = 1250 А; 02_Номинальный ток горизонтальных сборных шин панели_16: 16 = 1600 А; 02_Номинальный ток горизонтальных сборных шин панели_20: 20 = 2000 А; 02_Номинальный ток горизонтальных сборных шин панели_25: 25 = 2500 А; 02_Номинальный ток горизонтальных сборных шин панели_32: 32 = 3200 А; 02_Номинальный ток горизонтальных сборных шин панели_40: 40 = 4000 А; 02_Номинальный ток горизонтальных сборных шин панели_50: 50 = 5000 А; 02_Номинальный ток горизонтальных сборных шин панели_63: 63 = 6300 А; 03_Номинальный ток вертикальных шин_00: 00 - без сборных шин; 03_Номинальный ток вертикальных шин_06: 06 = 630 А; 03_Номинальный ток вертикальных шин_08: 08 = 800 А; 03_Номинальный ток вертикальных шин_10: 10 = 1000 А; 03_Номинальный ток вертикальных шин_12: 12 = 1250 А; 03_Номинальный ток вертикальных шин_16: 16 = 1600 А; 03_Номинальный ток вертикальных шин_20: 20 = 2000 А; 03_Номинальный ток вертикальных шин_25: 25 = 2500 А; 03_Номинальный ток вертикальных шин_32: 32 = 3200 А; 03_Номинальный ток вертикальных шин_40: 40 = 4000 А; 03_Номинальный ток вертикальных шин_50: 50 = 5000 А; 03_Номинальный ток вертикальных шин_63: 63 = 6300 А; 04_Ток КЗ шинной системы_A: A= 25; 04_Ток КЗ шинной системы_B: B = 36; 04_Ток КЗ шинной системы_C: C = 50; 04_Ток КЗ шинной системы_D: D = 65; 04_Ток КЗ шинной системы_E: E = 75; 04_Ток КЗ шинной системы_F: F = 85; 04_Ток КЗ шинной системы_G: G = 100; 05_Система заземления_C: C = TN-C; 05_Система заземления_D: D = TN-C-S; 05_Система заземления_I: I = IT; 05_Система заземления_S: S = TN-S; 05_Система заземления_T: T = TT; 06_Количество распределительных шин_3: 3 – полюса; 06_Количество распределительных шин_4: 4 – полюса; 07_Подключение_A: A - верхнее шинопроводом; 07_Подключение_B: B - верхнее кабелем; 07_Подключение_C: C - нижнее кабелем; 07_Подключение_D: D - боковое левое шинами; 07_Подключение_E: E - боковое правое шинами; 07_Подключение_Х: Х - без внешних силовых подключений; 08_Обслуживание_IP31: 1/2 - IP31; 08_Обслуживание_IP54: 3/4 - IP54; 09_Высота панели_Без цоколя: Без цоколя; 09_Высота панели_С цоколем: С цоколем; 11_Ширина кабельной колонны (при одностороннем обслуж)_0: 0 - отсутствует; 11_Ширина кабельной колонны (при одностороннем обслуж)_4 слева: 4 - 400 слева; 11_Ширина кабельной колонны (при одностороннем обслуж)_4 справа: 4 - 400 справа; 11_Ширина кабельной колонны (при одностороннем обслуж)_6 слева: 6 - 600 слева; 11_Ширина кабельной колонны (при одностороннем обслуж)_6 справа: 6 - 600 справа; 12_Секционирование_1a: 1a - без секционирования; 12_Секционирование_2a: 2a - секционирование; 12_Секционирование_2b: 2b - секционирование; 12_Секционирование_3a: 3a - секционирование; 12_Секционирование_3b: 3b - секционирование; 12_Секционирование_4a: 4a - секционирование; 12_Секционирование_4b: 4b - секционирование; Обслуживание: 1; Имя семейства: НВО_RAMPower_РаспределительнаяПанель_ОдинарныйКаркас_DKC
Type - Размеры - ADSK_Размер_Высота: 2000 mm; ADSK_Размер_Глубина: 800 mm; ADSK_Размер_Ширина: 1000 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: 2000 х 1000 х 800 (max 4000А, одностороннее обслуживание)
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 01_Название колонны: С - Панель комбинированная; 02_Номинальный ток горизонтальных сборных шин панели: 32 = 3200 А; 03_Номинальный ток вертикальных шин: 32 = 3200 А; 04_Ток КЗ шинной системы: G = 100; 05_Система заземления: S = TN-S; 06_Количество распределительных шин: 3 – полюса; 07_Подключение: B - верхнее кабелем; 08_Обслуживание: 3/4 - IP54; 09_Высота панели: С цоколем; 11_Ширина кабельной колонны (при одностороннем обслуж): 0 - отсутствует; 12_Секционирование: 3b - секционирование
Зависимости - Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 66
Прочее - IP31: no; Боковые стенки_Видимость: yes; Задняя стенка_Видимость: yes; Зона обслуживания_Видимость: yes; Зона обслуживания сзади_Видимость: no; Кабельная колонна слева: no; Кабельная колонна справа: no; Комлект ввода_Видимость: no; Ручка_Видимость: no; Цоколь_Видимость: yes; Код типа: НВО_RAMPower_РаспределительнаяПанель_ОдинарныйКаркас_DKC: 2000 х 1000 х 800 (max 4000А, одностороннее обслуживание); Семейство: НВО_RAMPower_РаспределительнаяПанель_ОдинарныйКаркас_DKC: 2000 х 1000 х 800 (max 4000А, одностороннее обслуживание); Семейство и типоразмер: НВО_RAMPower_РаспределительнаяПанель_ОдинарныйКаркас_DKC: 2000 х 1000 х 800 (max 4000А, одностороннее обслуживание); Тип: НВО_RAMPower_РаспределительнаяПанель_ОдинарныйКаркас_DKC: 2000 х 1000 х 800 (max 4000А, одностороннее обслуживание)
Размеры - Высота 2200: 0 mm; Комплект ввода_Высота: 0 mm; Высота стенок: 1950 mm; Объем: 7.308 m3; Площадь: 43.3199 m2; Цоколь: 100 mm; Ширина кабельной колонны: 600 mm; Ширина стенок: 760 mm
Стадии - Стадия возведения: Стадия 1
Строительство - Боковые стенки: yes; Вспомогательная надпись: yes; Задняя стенка: yes; Закрытие свободного пространства: 0; Зона обслуживания: yes; Режим установки оборудования: no; Стойки: yes
Текст - DKC_Артикул_01_Название колонны: C; DKC_Артикул_02_Номинальный ток горизонтальных сборных шин панели: 32; DKC_Артикул_03_Номинальный ток вертикальных шин: 32; DKC_Артикул_04_Ток КЗ шинной системы: G; DKC_Артикул_05_Система заземления: S; DKC_Артикул_06_Количество распределительных шин: 3; DKC_Артикул_07_Подключение: B; DKC_Артикул_08_Обслуживание: 3; DKC_Артикул_09_Высота панели: Y; DKC_Артикул_10_Ширина и глубина основной колонны: 18; DKC_Артикул_11_Ширина кабельной колонны (при одностороннем обслуж): 0; DKC_Артикул_12_Секционирование: 3b
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: 2000 х 400 x 600 (max 2500А, одностороннее обслуживание), НВО_RAMPower_РаспределительнаяПанель_ОдинарныйКаркас_DKC:2000 х 400 x 600 (max 2500А, одностороннее обслуживание):696261
In: Этаж 01
Type - Material: DKC_Красный_Лого, DKC_Металл_Светлый, DKC_Металл_Серый, DKC_Зона обслуживания
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Наименование: Распределительная панель, одинарный каркас, 2000 х 400 x 600 (max 2500А, одностороннее обслуживание); ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2; DKC_Ударопрочность: IK10
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: 2000 х 400 x 600 (max 2500А, одностороннее обслуживание); Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 01_Название колонны_A: A - Панель для воздушных выключателей; 01_Название колонны_C: С - Панель комбинированная; 01_Название колонны_M: M - Панель управления электродвигателями; 02_Номинальный ток горизонтальных сборных шин панели_00: 00 - без сборных шин; 02_Номинальный ток горизонтальных сборных шин панели_06: 06 = 630 А; 02_Номинальный ток горизонтальных сборных шин панели_08: 08 = 800 А; 02_Номинальный ток горизонтальных сборных шин панели_10: 10 = 1000 А; 02_Номинальный ток горизонтальных сборных шин панели_12: 12 = 1250 А; 02_Номинальный ток горизонтальных сборных шин панели_16: 16 = 1600 А; 02_Номинальный ток горизонтальных сборных шин панели_20: 20 = 2000 А; 02_Номинальный ток горизонтальных сборных шин панели_25: 25 = 2500 А; 02_Номинальный ток горизонтальных сборных шин панели_32: 32 = 3200 А; 02_Номинальный ток горизонтальных сборных шин панели_40: 40 = 4000 А; 02_Номинальный ток горизонтальных сборных шин панели_50: 50 = 5000 А; 02_Номинальный ток горизонтальных сборных шин панели_63: 63 = 6300 А; 03_Номинальный ток вертикальных шин_00: 00 - без сборных шин; 03_Номинальный ток вертикальных шин_06: 06 = 630 А; 03_Номинальный ток вертикальных шин_08: 08 = 800 А; 03_Номинальный ток вертикальных шин_10: 10 = 1000 А; 03_Номинальный ток вертикальных шин_12: 12 = 1250 А; 03_Номинальный ток вертикальных шин_16: 16 = 1600 А; 03_Номинальный ток вертикальных шин_20: 20 = 2000 А; 03_Номинальный ток вертикальных шин_25: 25 = 2500 А; 03_Номинальный ток вертикальных шин_32: 32 = 3200 А; 03_Номинальный ток вертикальных шин_40: 40 = 4000 А; 03_Номинальный ток вертикальных шин_50: 50 = 5000 А; 03_Номинальный ток вертикальных шин_63: 63 = 6300 А; 04_Ток КЗ шинной системы_A: A= 25; 04_Ток КЗ шинной системы_B: B = 36; 04_Ток КЗ шинной системы_C: C = 50; 04_Ток КЗ шинной системы_D: D = 65; 04_Ток КЗ шинной системы_E: E = 75; 04_Ток КЗ шинной системы_F: F = 85; 04_Ток КЗ шинной системы_G: G = 100; 05_Система заземления_C: C = TN-C; 05_Система заземления_D: D = TN-C-S; 05_Система заземления_I: I = IT; 05_Система заземления_S: S = TN-S; 05_Система заземления_T: T = TT; 06_Количество распределительных шин_3: 3 – полюса; 06_Количество распределительных шин_4: 4 – полюса; 07_Подключение_A: A - верхнее шинопроводом; 07_Подключение_B: B - верхнее кабелем; 07_Подключение_C: C - нижнее кабелем; 07_Подключение_D: D - боковое левое шинами; 07_Подключение_E: E - боковое правое шинами; 07_Подключение_Х: Х - без внешних силовых подключений; 08_Обслуживание_IP31: 1/2 - IP31; 08_Обслуживание_IP54: 3/4 - IP54; 09_Высота панели_Без цоколя: Без цоколя; 09_Высота панели_С цоколем: С цоколем; 11_Ширина кабельной колонны (при одностороннем обслуж)_0: 0 - отсутствует; 11_Ширина кабельной колонны (при одностороннем обслуж)_4 слева: 4 - 400 слева; 11_Ширина кабельной колонны (при одностороннем обслуж)_4 справа: 4 - 400 справа; 11_Ширина кабельной колонны (при одностороннем обслуж)_6 слева: 6 - 600 слева; 11_Ширина кабельной колонны (при одностороннем обслуж)_6 справа: 6 - 600 справа; 12_Секционирование_1a: 1a - без секционирования; 12_Секционирование_2a: 2a - секционирование; 12_Секционирование_2b: 2b - секционирование; 12_Секционирование_3a: 3a - секционирование; 12_Секционирование_3b: 3b - секционирование; 12_Секционирование_4a: 4a - секционирование; 12_Секционирование_4b: 4b - секционирование; Имя семейства: НВО_RAMPower_РаспределительнаяПанель_ОдинарныйКаркас_DKC; Обслуживание: 1
Type - Размеры - ADSK_Размер_Высота: 2000 mm; ADSK_Размер_Глубина: 600 mm; ADSK_Размер_Ширина: 400 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: 2000 х 400 x 600 (max 2500А, одностороннее обслуживание)
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 01_Название колонны: С - Панель комбинированная; 02_Номинальный ток горизонтальных сборных шин панели: 32 = 3200 А; 03_Номинальный ток вертикальных шин: 32 = 3200 А; 04_Ток КЗ шинной системы: G = 100; 05_Система заземления: S = TN-S; 06_Количество распределительных шин: 3 – полюса; 07_Подключение: B - верхнее кабелем; 08_Обслуживание: 3/4 - IP54; 09_Высота панели: С цоколем; 11_Ширина кабельной колонны (при одностороннем обслуж): 0 - отсутствует; 12_Секционирование: 3b - секционирование
Зависимости - Основа: Уровень : Этаж 01; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Марка: 56
Прочее - IP31: no; Боковые стенки_Видимость: yes; Задняя стенка_Видимость: yes; Зона обслуживания_Видимость: yes; Зона обслуживания сзади_Видимость: no; Кабельная колонна слева: no; Кабельная колонна справа: no; Код типа: НВО_RAMPower_РаспределительнаяПанель_ОдинарныйКаркас_DKC: 2000 х 400 x 600 (max 2500А, одностороннее обслуживание); Комлект ввода_Видимость: no; Ручка_Видимость: no; Семейство: НВО_RAMPower_РаспределительнаяПанель_ОдинарныйКаркас_DKC: 2000 х 400 x 600 (max 2500А, одностороннее обслуживание); Семейство и типоразмер: НВО_RAMPower_РаспределительнаяПанель_ОдинарныйКаркас_DKC: 2000 х 400 x 600 (max 2500А, одностороннее обслуживание); Тип: НВО_RAMPower_РаспределительнаяПанель_ОдинарныйКаркас_DKC: 2000 х 400 x 600 (max 2500А, одностороннее обслуживание); Цоколь_Видимость: yes
Размеры - Высота 2200: 0 mm; Высота стенок: 1950 mm; Комплект ввода_Высота: 0 mm; Объем: 3.864 m3; Площадь: 30.1957 m2; Цоколь: 100 mm; Ширина кабельной колонны: 600 mm; Ширина стенок: 560 mm
Стадии - Стадия возведения: Стадия 1
Строительство - Боковые стенки: yes; Вспомогательная надпись: yes; Задняя стенка: yes; Закрытие свободного пространства: 0; Зона обслуживания: yes; Режим установки оборудования: no; Стойки: yes
Текст - DKC_Артикул_01_Название колонны: C; DKC_Артикул_02_Номинальный ток горизонтальных сборных шин панели: 32; DKC_Артикул_03_Номинальный ток вертикальных шин: 32; DKC_Артикул_04_Ток КЗ шинной системы: G; DKC_Артикул_05_Система заземления: S; DKC_Артикул_06_Количество распределительных шин: 3; DKC_Артикул_07_Подключение: B; DKC_Артикул_08_Обслуживание: 3; DKC_Артикул_09_Высота панели: Y; DKC_Артикул_10_Ширина и глубина основной колонны: 46; DKC_Артикул_11_Ширина кабельной колонны (при одностороннем обслуж): 0; DKC_Артикул_12_Секционирование: 3b
Электросети - Нагрузки - Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Усредненный коэффициент спроса: 1; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: 2000 х 400 x 800 (max 4000А, двухстороннее обслуживание), НВО_RAMPower_РаспределительнаяПанель_ОдинарныйКаркас_DKC:2000 х 400 x 800 (max 4000А, двухстороннее обслуживание):696266
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Красный_Лого, DKC_Металл_Светлый, DKC_Зона обслуживания
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Распределительная панель, одинарный каркас, 2000 х 400 x 800 (max 4000А, двухстороннее обслуживание); ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2; DKC_Ударопрочность: IK10
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: 2000 х 400 x 800 (max 4000А, двухстороннее обслуживание); Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 01_Название колонны_A: A - Панель для воздушных выключателей; 01_Название колонны_C: С - Панель комбинированная; 01_Название колонны_M: M - Панель управления электродвигателями; 02_Номинальный ток горизонтальных сборных шин панели_00: 00 - без сборных шин; 02_Номинальный ток горизонтальных сборных шин панели_06: 06 = 630 А; 02_Номинальный ток горизонтальных сборных шин панели_08: 08 = 800 А; 02_Номинальный ток горизонтальных сборных шин панели_10: 10 = 1000 А; 02_Номинальный ток горизонтальных сборных шин панели_12: 12 = 1250 А; 02_Номинальный ток горизонтальных сборных шин панели_16: 16 = 1600 А; 02_Номинальный ток горизонтальных сборных шин панели_20: 20 = 2000 А; 02_Номинальный ток горизонтальных сборных шин панели_25: 25 = 2500 А; 02_Номинальный ток горизонтальных сборных шин панели_32: 32 = 3200 А; 02_Номинальный ток горизонтальных сборных шин панели_40: 40 = 4000 А; 02_Номинальный ток горизонтальных сборных шин панели_50: 50 = 5000 А; 02_Номинальный ток горизонтальных сборных шин панели_63: 63 = 6300 А; 03_Номинальный ток вертикальных шин_00: 00 - без сборных шин; 03_Номинальный ток вертикальных шин_06: 06 = 630 А; 03_Номинальный ток вертикальных шин_08: 08 = 800 А; 03_Номинальный ток вертикальных шин_10: 10 = 1000 А; 03_Номинальный ток вертикальных шин_12: 12 = 1250 А; 03_Номинальный ток вертикальных шин_16: 16 = 1600 А; 03_Номинальный ток вертикальных шин_20: 20 = 2000 А; 03_Номинальный ток вертикальных шин_25: 25 = 2500 А; 03_Номинальный ток вертикальных шин_32: 32 = 3200 А; 03_Номинальный ток вертикальных шин_40: 40 = 4000 А; 03_Номинальный ток вертикальных шин_50: 50 = 5000 А; 03_Номинальный ток вертикальных шин_63: 63 = 6300 А; 04_Ток КЗ шинной системы_A: A= 25; 04_Ток КЗ шинной системы_B: B = 36; 04_Ток КЗ шинной системы_C: C = 50; 04_Ток КЗ шинной системы_D: D = 65; 04_Ток КЗ шинной системы_E: E = 75; 04_Ток КЗ шинной системы_F: F = 85; 04_Ток КЗ шинной системы_G: G = 100; 05_Система заземления_C: C = TN-C; 05_Система заземления_D: D = TN-C-S; 05_Система заземления_I: I = IT; 05_Система заземления_S: S = TN-S; 05_Система заземления_T: T = TT; 06_Количество распределительных шин_3: 3 – полюса; 06_Количество распределительных шин_4: 4 – полюса; 07_Подключение_A: A - верхнее шинопроводом; 07_Подключение_B: B - верхнее кабелем; 07_Подключение_C: C - нижнее кабелем; 07_Подключение_D: D - боковое левое шинами; 07_Подключение_E: E - боковое правое шинами; 07_Подключение_Х: Х - без внешних силовых подключений; 08_Обслуживание_IP31: 1/2 - IP31; 08_Обслуживание_IP54: 3/4 - IP54; 09_Высота панели_Без цоколя: Без цоколя; 09_Высота панели_С цоколем: С цоколем; 11_Ширина кабельной колонны (при одностороннем обслуж)_0: 0 - отсутствует; 11_Ширина кабельной колонны (при одностороннем обслуж)_4 слева: 4 - 400 слева; 11_Ширина кабельной колонны (при одностороннем обслуж)_4 справа: 4 - 400 справа; 11_Ширина кабельной колонны (при одностороннем обслуж)_6 слева: 6 - 600 слева; 11_Ширина кабельной колонны (при одностороннем обслуж)_6 справа: 6 - 600 справа; 12_Секционирование_1a: 1a - без секционирования; 12_Секционирование_2a: 2a - секционирование; 12_Секционирование_2b: 2b - секционирование; 12_Секционирование_3a: 3a - секционирование; 12_Секционирование_3b: 3b - секционирование; 12_Секционирование_4a: 4a - секционирование; 12_Секционирование_4b: 4b - секционирование; Имя семейства: НВО_RAMPower_РаспределительнаяПанель_ОдинарныйКаркас_DKC; Обслуживание: 2
Type - Размеры - ADSK_Размер_Высота: 2000 mm; ADSK_Размер_Глубина: 800 mm; ADSK_Размер_Ширина: 400 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: 2000 х 400 x 800 (max 4000А, двухстороннее обслуживание)
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 01_Название колонны: С - Панель комбинированная; 02_Номинальный ток горизонтальных сборных шин панели: 32 = 3200 А; 03_Номинальный ток вертикальных шин: 32 = 3200 А; 04_Ток КЗ шинной системы: G = 100; 05_Система заземления: S = TN-S; 06_Количество распределительных шин: 3 – полюса; 07_Подключение: B - верхнее кабелем; 08_Обслуживание: 3/4 - IP54; 09_Высота панели: С цоколем; 11_Ширина кабельной колонны (при одностороннем обслуж): 0 - отсутствует; 12_Секционирование: 3b - секционирование
Зависимости - Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 58
Прочее - IP31: no; Боковые стенки_Видимость: yes; Задняя стенка_Видимость: yes; Зона обслуживания_Видимость: yes; Кабельная колонна слева: no; Кабельная колонна справа: no; Комлект ввода_Видимость: no; Цоколь_Видимость: yes; Зона обслуживания сзади_Видимость: yes; Код типа: НВО_RAMPower_РаспределительнаяПанель_ОдинарныйКаркас_DKC: 2000 х 400 x 800 (max 4000А, двухстороннее обслуживание); Ручка_Видимость: yes; Семейство: НВО_RAMPower_РаспределительнаяПанель_ОдинарныйКаркас_DKC: 2000 х 400 x 800 (max 4000А, двухстороннее обслуживание); Семейство и типоразмер: НВО_RAMPower_РаспределительнаяПанель_ОдинарныйКаркас_DKC: 2000 х 400 x 800 (max 4000А, двухстороннее обслуживание); Тип: НВО_RAMPower_РаспределительнаяПанель_ОдинарныйКаркас_DKC: 2000 х 400 x 800 (max 4000А, двухстороннее обслуживание)
Размеры - Высота 2200: 0 mm; Комплект ввода_Высота: 0 mm; Высота стенок: 1950 mm; Объем: 6.384 m3; Площадь: 33.2423 m2; Цоколь: 100 mm; Ширина кабельной колонны: 600 mm; Ширина стенок: 760 mm
Стадии - Стадия возведения: Стадия 1
Строительство - Боковые стенки: yes; Вспомогательная надпись: yes; Задняя стенка: yes; Закрытие свободного пространства: 0; Зона обслуживания: yes; Режим установки оборудования: no; Стойки: yes
Текст - DKC_Артикул_01_Название колонны: C; DKC_Артикул_02_Номинальный ток горизонтальных сборных шин панели: 32; DKC_Артикул_03_Номинальный ток вертикальных шин: 32; DKC_Артикул_04_Ток КЗ шинной системы: G; DKC_Артикул_05_Система заземления: S; DKC_Артикул_06_Количество распределительных шин: 3; DKC_Артикул_07_Подключение: B; DKC_Артикул_08_Обслуживание: 4; DKC_Артикул_09_Высота панели: Y; DKC_Артикул_10_Ширина и глубина основной колонны: 48; DKC_Артикул_11_Ширина кабельной колонны (при одностороннем обслуж): 0; DKC_Артикул_12_Секционирование: 3b
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: 2000 х 400 x 800 (max 4000А, одностороннее обслуживание), НВО_RAMPower_РаспределительнаяПанель_ОдинарныйКаркас_DKC:2000 х 400 x 800 (max 4000А, одностороннее обслуживание):696265
In: Этаж 01
Type - Material: DKC_Красный_Лого, DKC_Металл_Светлый, DKC_Металл_Серый, DKC_Зона обслуживания
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Распределительная панель, одинарный каркас, 2000 х 400 x 800 (max 4000А, одностороннее обслуживание); ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2; DKC_Ударопрочность: IK10
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: 2000 х 400 x 800 (max 4000А, одностороннее обслуживание); Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 01_Название колонны_A: A - Панель для воздушных выключателей; 01_Название колонны_C: С - Панель комбинированная; 01_Название колонны_M: M - Панель управления электродвигателями; 02_Номинальный ток горизонтальных сборных шин панели_00: 00 - без сборных шин; 02_Номинальный ток горизонтальных сборных шин панели_06: 06 = 630 А; 02_Номинальный ток горизонтальных сборных шин панели_08: 08 = 800 А; 02_Номинальный ток горизонтальных сборных шин панели_10: 10 = 1000 А; 02_Номинальный ток горизонтальных сборных шин панели_12: 12 = 1250 А; 02_Номинальный ток горизонтальных сборных шин панели_16: 16 = 1600 А; 02_Номинальный ток горизонтальных сборных шин панели_20: 20 = 2000 А; 02_Номинальный ток горизонтальных сборных шин панели_25: 25 = 2500 А; 02_Номинальный ток горизонтальных сборных шин панели_32: 32 = 3200 А; 02_Номинальный ток горизонтальных сборных шин панели_40: 40 = 4000 А; 02_Номинальный ток горизонтальных сборных шин панели_50: 50 = 5000 А; 02_Номинальный ток горизонтальных сборных шин панели_63: 63 = 6300 А; 03_Номинальный ток вертикальных шин_00: 00 - без сборных шин; 03_Номинальный ток вертикальных шин_06: 06 = 630 А; 03_Номинальный ток вертикальных шин_08: 08 = 800 А; 03_Номинальный ток вертикальных шин_10: 10 = 1000 А; 03_Номинальный ток вертикальных шин_12: 12 = 1250 А; 03_Номинальный ток вертикальных шин_16: 16 = 1600 А; 03_Номинальный ток вертикальных шин_20: 20 = 2000 А; 03_Номинальный ток вертикальных шин_25: 25 = 2500 А; 03_Номинальный ток вертикальных шин_32: 32 = 3200 А; 03_Номинальный ток вертикальных шин_40: 40 = 4000 А; 03_Номинальный ток вертикальных шин_50: 50 = 5000 А; 03_Номинальный ток вертикальных шин_63: 63 = 6300 А; 04_Ток КЗ шинной системы_A: A= 25; 04_Ток КЗ шинной системы_B: B = 36; 04_Ток КЗ шинной системы_C: C = 50; 04_Ток КЗ шинной системы_D: D = 65; 04_Ток КЗ шинной системы_E: E = 75; 04_Ток КЗ шинной системы_F: F = 85; 04_Ток КЗ шинной системы_G: G = 100; 05_Система заземления_C: C = TN-C; 05_Система заземления_D: D = TN-C-S; 05_Система заземления_I: I = IT; 05_Система заземления_S: S = TN-S; 05_Система заземления_T: T = TT; 06_Количество распределительных шин_3: 3 – полюса; 06_Количество распределительных шин_4: 4 – полюса; 07_Подключение_A: A - верхнее шинопроводом; 07_Подключение_B: B - верхнее кабелем; 07_Подключение_C: C - нижнее кабелем; 07_Подключение_D: D - боковое левое шинами; 07_Подключение_E: E - боковое правое шинами; 07_Подключение_Х: Х - без внешних силовых подключений; 08_Обслуживание_IP31: 1/2 - IP31; 08_Обслуживание_IP54: 3/4 - IP54; 09_Высота панели_Без цоколя: Без цоколя; 09_Высота панели_С цоколем: С цоколем; 11_Ширина кабельной колонны (при одностороннем обслуж)_0: 0 - отсутствует; 11_Ширина кабельной колонны (при одностороннем обслуж)_4 слева: 4 - 400 слева; 11_Ширина кабельной колонны (при одностороннем обслуж)_4 справа: 4 - 400 справа; 11_Ширина кабельной колонны (при одностороннем обслуж)_6 слева: 6 - 600 слева; 11_Ширина кабельной колонны (при одностороннем обслуж)_6 справа: 6 - 600 справа; 12_Секционирование_1a: 1a - без секционирования; 12_Секционирование_2a: 2a - секционирование; 12_Секционирование_2b: 2b - секционирование; 12_Секционирование_3a: 3a - секционирование; 12_Секционирование_3b: 3b - секционирование; 12_Секционирование_4a: 4a - секционирование; 12_Секционирование_4b: 4b - секционирование; Обслуживание: 1; Имя семейства: НВО_RAMPower_РаспределительнаяПанель_ОдинарныйКаркас_DKC
Type - Размеры - ADSK_Размер_Высота: 2000 mm; ADSK_Размер_Глубина: 800 mm; ADSK_Размер_Ширина: 400 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: 2000 х 400 x 800 (max 4000А, одностороннее обслуживание)
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 01_Название колонны: С - Панель комбинированная; 02_Номинальный ток горизонтальных сборных шин панели: 32 = 3200 А; 03_Номинальный ток вертикальных шин: 32 = 3200 А; 04_Ток КЗ шинной системы: G = 100; 05_Система заземления: S = TN-S; 06_Количество распределительных шин: 3 – полюса; 07_Подключение: B - верхнее кабелем; 08_Обслуживание: 3/4 - IP54; 09_Высота панели: С цоколем; 11_Ширина кабельной колонны (при одностороннем обслуж): 0 - отсутствует; 12_Секционирование: 3b - секционирование
Зависимости - Перемещать с соседними элементами: no; Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 57
Прочее - IP31: no; Боковые стенки_Видимость: yes; Задняя стенка_Видимость: yes; Зона обслуживания_Видимость: yes; Зона обслуживания сзади_Видимость: no; Кабельная колонна слева: no; Кабельная колонна справа: no; Комлект ввода_Видимость: no; Ручка_Видимость: no; Цоколь_Видимость: yes; Код типа: НВО_RAMPower_РаспределительнаяПанель_ОдинарныйКаркас_DKC: 2000 х 400 x 800 (max 4000А, одностороннее обслуживание); Семейство: НВО_RAMPower_РаспределительнаяПанель_ОдинарныйКаркас_DKC: 2000 х 400 x 800 (max 4000А, одностороннее обслуживание); Семейство и типоразмер: НВО_RAMPower_РаспределительнаяПанель_ОдинарныйКаркас_DKC: 2000 х 400 x 800 (max 4000А, одностороннее обслуживание); Тип: НВО_RAMPower_РаспределительнаяПанель_ОдинарныйКаркас_DKC: 2000 х 400 x 800 (max 4000А, одностороннее обслуживание)
Размеры - Высота 2200: 0 mm; Комплект ввода_Высота: 0 mm; Высота стенок: 1950 mm; Объем: 4.536 m3; Площадь: 33.2423 m2; Цоколь: 100 mm; Ширина кабельной колонны: 600 mm; Ширина стенок: 760 mm
Стадии - Стадия возведения: Стадия 1
Строительство - Боковые стенки: yes; Вспомогательная надпись: yes; Задняя стенка: yes; Закрытие свободного пространства: 0; Зона обслуживания: yes; Режим установки оборудования: no; Стойки: yes
Текст - DKC_Артикул_01_Название колонны: C; DKC_Артикул_02_Номинальный ток горизонтальных сборных шин панели: 32; DKC_Артикул_03_Номинальный ток вертикальных шин: 32; DKC_Артикул_04_Ток КЗ шинной системы: G; DKC_Артикул_05_Система заземления: S; DKC_Артикул_06_Количество распределительных шин: 3; DKC_Артикул_07_Подключение: B; DKC_Артикул_08_Обслуживание: 3; DKC_Артикул_09_Высота панели: Y; DKC_Артикул_10_Ширина и глубина основной колонны: 48; DKC_Артикул_11_Ширина кабельной колонны (при одностороннем обслуж): 0; DKC_Артикул_12_Секционирование: 3b
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: 2000 х 600 х 600 (max 2500А, одностороннее обслуживание), НВО_RAMPower_РаспределительнаяПанель_ОдинарныйКаркас_DKC:2000 х 600 х 600 (max 2500А, одностороннее обслуживание):696268
In: Этаж 01
Type - Material: DKC_Красный_Лого, DKC_Металл_Светлый, DKC_Металл_Серый, DKC_Зона обслуживания
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Распределительная панель, одинарный каркас, 2000 х 600 х 600 (max 2500А, одностороннее обслуживание); ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2; DKC_Ударопрочность: IK10
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: 2000 х 600 х 600 (max 2500А, одностороннее обслуживание); Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 01_Название колонны_A: A - Панель для воздушных выключателей; 01_Название колонны_C: С - Панель комбинированная; 01_Название колонны_M: M - Панель управления электродвигателями; 02_Номинальный ток горизонтальных сборных шин панели_00: 00 - без сборных шин; 02_Номинальный ток горизонтальных сборных шин панели_06: 06 = 630 А; 02_Номинальный ток горизонтальных сборных шин панели_08: 08 = 800 А; 02_Номинальный ток горизонтальных сборных шин панели_10: 10 = 1000 А; 02_Номинальный ток горизонтальных сборных шин панели_12: 12 = 1250 А; 02_Номинальный ток горизонтальных сборных шин панели_16: 16 = 1600 А; 02_Номинальный ток горизонтальных сборных шин панели_20: 20 = 2000 А; 02_Номинальный ток горизонтальных сборных шин панели_25: 25 = 2500 А; 02_Номинальный ток горизонтальных сборных шин панели_32: 32 = 3200 А; 02_Номинальный ток горизонтальных сборных шин панели_40: 40 = 4000 А; 02_Номинальный ток горизонтальных сборных шин панели_50: 50 = 5000 А; 02_Номинальный ток горизонтальных сборных шин панели_63: 63 = 6300 А; 03_Номинальный ток вертикальных шин_00: 00 - без сборных шин; 03_Номинальный ток вертикальных шин_06: 06 = 630 А; 03_Номинальный ток вертикальных шин_08: 08 = 800 А; 03_Номинальный ток вертикальных шин_10: 10 = 1000 А; 03_Номинальный ток вертикальных шин_12: 12 = 1250 А; 03_Номинальный ток вертикальных шин_16: 16 = 1600 А; 03_Номинальный ток вертикальных шин_20: 20 = 2000 А; 03_Номинальный ток вертикальных шин_25: 25 = 2500 А; 03_Номинальный ток вертикальных шин_32: 32 = 3200 А; 03_Номинальный ток вертикальных шин_40: 40 = 4000 А; 03_Номинальный ток вертикальных шин_50: 50 = 5000 А; 03_Номинальный ток вертикальных шин_63: 63 = 6300 А; 04_Ток КЗ шинной системы_A: A= 25; 04_Ток КЗ шинной системы_B: B = 36; 04_Ток КЗ шинной системы_C: C = 50; 04_Ток КЗ шинной системы_D: D = 65; 04_Ток КЗ шинной системы_E: E = 75; 04_Ток КЗ шинной системы_F: F = 85; 04_Ток КЗ шинной системы_G: G = 100; 05_Система заземления_C: C = TN-C; 05_Система заземления_D: D = TN-C-S; 05_Система заземления_I: I = IT; 05_Система заземления_S: S = TN-S; 05_Система заземления_T: T = TT; 06_Количество распределительных шин_3: 3 – полюса; 06_Количество распределительных шин_4: 4 – полюса; 07_Подключение_A: A - верхнее шинопроводом; 07_Подключение_B: B - верхнее кабелем; 07_Подключение_C: C - нижнее кабелем; 07_Подключение_D: D - боковое левое шинами; 07_Подключение_E: E - боковое правое шинами; 07_Подключение_Х: Х - без внешних силовых подключений; 08_Обслуживание_IP31: 1/2 - IP31; 08_Обслуживание_IP54: 3/4 - IP54; 09_Высота панели_Без цоколя: Без цоколя; 09_Высота панели_С цоколем: С цоколем; 11_Ширина кабельной колонны (при одностороннем обслуж)_0: 0 - отсутствует; 11_Ширина кабельной колонны (при одностороннем обслуж)_4 слева: 4 - 400 слева; 11_Ширина кабельной колонны (при одностороннем обслуж)_4 справа: 4 - 400 справа; 11_Ширина кабельной колонны (при одностороннем обслуж)_6 слева: 6 - 600 слева; 11_Ширина кабельной колонны (при одностороннем обслуж)_6 справа: 6 - 600 справа; 12_Секционирование_1a: 1a - без секционирования; 12_Секционирование_2a: 2a - секционирование; 12_Секционирование_2b: 2b - секционирование; 12_Секционирование_3a: 3a - секционирование; 12_Секционирование_3b: 3b - секционирование; 12_Секционирование_4a: 4a - секционирование; 12_Секционирование_4b: 4b - секционирование; Обслуживание: 1; Имя семейства: НВО_RAMPower_РаспределительнаяПанель_ОдинарныйКаркас_DKC
Type - Размеры - ADSK_Размер_Высота: 2000 mm; ADSK_Размер_Глубина: 600 mm; ADSK_Размер_Ширина: 600 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: 2000 х 600 х 600 (max 2500А, одностороннее обслуживание)
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 01_Название колонны: С - Панель комбинированная; 02_Номинальный ток горизонтальных сборных шин панели: 32 = 3200 А; 03_Номинальный ток вертикальных шин: 32 = 3200 А; 04_Ток КЗ шинной системы: G = 100; 05_Система заземления: S = TN-S; 06_Количество распределительных шин: 3 – полюса; 07_Подключение: B - верхнее кабелем; 08_Обслуживание: 3/4 - IP54; 09_Высота панели: С цоколем; 11_Ширина кабельной колонны (при одностороннем обслуж): 0 - отсутствует; 12_Секционирование: 3b - секционирование
Зависимости - Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Марка: 59
