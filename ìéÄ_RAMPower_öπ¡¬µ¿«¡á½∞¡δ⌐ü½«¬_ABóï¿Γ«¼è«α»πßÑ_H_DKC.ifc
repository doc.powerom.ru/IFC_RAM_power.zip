Properties of the parts of a building model (IFC2X3), part 3 of 4

# IfcBuildingElementProxy: LSIS electric, TS630 (P-MO), 600х250, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC:LSIS electric, TS630 (P-MO), 600х250:881028
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок AB в литом корпусе (H), LSIS electric, TS630 (P-MO), 600х250; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: LSIS electric, TS630 (P-MO), 600х250; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 06; 05_Производитель силовых аппаратов: L; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC
Type - Размеры - ADSK_Размер_Высота: 250 mm; ADSK_Размер_Ширина: 600 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: LSIS electric, TS630 (P-MO), 600х250
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: C - горизонтальный односторонний; 06_Номер схемного решения_1 часть: 2хх - АВ в литом корпусе; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 224
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: LSIS electric, TS630 (P-MO), 600х250; Семейство: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: LSIS electric, TS630 (P-MO), 600х250; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: LSIS electric, TS630 (P-MO), 600х250; Тип: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: LSIS electric, TS630 (P-MO), 600х250
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.00170661 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 5P; DKC_Артикул ФБ_02_Установка: C; DKC_Артикул ФБ_03_Номинальный ток: 06; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: L; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 2; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: Schneider electric, NSX250 (F, F-MO, P, P-MO), 600х150, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC:Schneider electric, NSX250 (F, F-MO, P, P-MO), 600х150:881089
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок AB в литом корпусе (H), Schneider electric, NSX250 (F, F-MO, P, P-MO), 600х150; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: Schneider electric, NSX250 (F, F-MO, P, P-MO), 600х150; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 72; 05_Производитель силовых аппаратов: E; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC
Type - Размеры - ADSK_Размер_Высота: 150 mm; ADSK_Размер_Ширина: 600 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: Schneider electric, NSX250 (F, F-MO, P, P-MO), 600х150
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: C - горизонтальный односторонний; 06_Номер схемного решения_1 часть: 2хх - АВ в литом корпусе; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 225
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: Schneider electric, NSX250 (F, F-MO, P, P-MO), 600х150; Семейство: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: Schneider electric, NSX250 (F, F-MO, P, P-MO), 600х150; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: Schneider electric, NSX250 (F, F-MO, P, P-MO), 600х150; Тип: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: Schneider electric, NSX250 (F, F-MO, P, P-MO), 600х150
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.0014588 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 3P; DKC_Артикул ФБ_02_Установка: C; DKC_Артикул ФБ_03_Номинальный ток: 72; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: E; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 2; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: Schneider electric, NSX250 (W, W-MO), 600х250, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC:Schneider electric, NSX250 (W, W-MO), 600х250:881091
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок AB в литом корпусе (H), Schneider electric, NSX250 (W, W-MO), 600х250; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: Schneider electric, NSX250 (W, W-MO), 600х250; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 72; 05_Производитель силовых аппаратов: E; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC
Type - Размеры - ADSK_Размер_Высота: 250 mm; ADSK_Размер_Ширина: 600 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: Schneider electric, NSX250 (W, W-MO), 600х250
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: C - горизонтальный односторонний; 06_Номер схемного решения_1 часть: 2хх - АВ в литом корпусе; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Марка: 226
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: Schneider electric, NSX250 (W, W-MO), 600х250; Семейство: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: Schneider electric, NSX250 (W, W-MO), 600х250; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: Schneider electric, NSX250 (W, W-MO), 600х250; Тип: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: Schneider electric, NSX250 (W, W-MO), 600х250
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.00170661 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 5P; DKC_Артикул ФБ_02_Установка: C; DKC_Артикул ФБ_03_Номинальный ток: 72; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: E; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 2; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: Schneider electric, NSX630 (F, F-MO, P), 600х200, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC:Schneider electric, NSX630 (F, F-MO, P), 600х200:881092
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок AB в литом корпусе (H), Schneider electric, NSX630 (F, F-MO, P), 600х200; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: Schneider electric, NSX630 (F, F-MO, P), 600х200; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 06; 05_Производитель силовых аппаратов: E; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC
Type - Размеры - ADSK_Размер_Высота: 200 mm; ADSK_Размер_Ширина: 600 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: Schneider electric, NSX630 (F, F-MO, P), 600х200
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: C - горизонтальный односторонний; 06_Номер схемного решения_1 часть: 2хх - АВ в литом корпусе; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 227
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: Schneider electric, NSX630 (F, F-MO, P), 600х200; Семейство: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: Schneider electric, NSX630 (F, F-MO, P), 600х200; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: Schneider electric, NSX630 (F, F-MO, P), 600х200; Тип: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: Schneider electric, NSX630 (F, F-MO, P), 600х200
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.00158271 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 4P; DKC_Артикул ФБ_02_Установка: C; DKC_Артикул ФБ_03_Номинальный ток: 06; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: E; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 2; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: Schneider electric, NSX630 (P-MO), 600х250, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC:Schneider electric, NSX630 (P-MO), 600х250:881114
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок AB в литом корпусе (H), Schneider electric, NSX630 (P-MO), 600х250; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: Schneider electric, NSX630 (P-MO), 600х250; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 06; 05_Производитель силовых аппаратов: E; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC
Type - Размеры - ADSK_Размер_Высота: 250 mm; ADSK_Размер_Ширина: 600 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: Schneider electric, NSX630 (P-MO), 600х250
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: C - горизонтальный односторонний; 06_Номер схемного решения_1 часть: 2хх - АВ в литом корпусе; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 228
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: Schneider electric, NSX630 (P-MO), 600х250; Семейство: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: Schneider electric, NSX630 (P-MO), 600х250; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: Schneider electric, NSX630 (P-MO), 600х250; Тип: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: Schneider electric, NSX630 (P-MO), 600х250
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.00170661 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 5P; DKC_Артикул ФБ_02_Установка: C; DKC_Артикул ФБ_03_Номинальный ток: 06; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: E; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 2; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: Schneider electric, NSX630 (W), 600х300, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC:Schneider electric, NSX630 (W), 600х300:881115
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок AB в литом корпусе (H), Schneider electric, NSX630 (W), 600х300; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: Schneider electric, NSX630 (W), 600х300; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 06; 05_Производитель силовых аппаратов: E; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC
Type - Размеры - ADSK_Размер_Высота: 300 mm; ADSK_Размер_Ширина: 600 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: Schneider electric, NSX630 (W), 600х300
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: C - горизонтальный односторонний; 06_Номер схемного решения_1 часть: 2хх - АВ в литом корпусе; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 229
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: Schneider electric, NSX630 (W), 600х300; Семейство: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: Schneider electric, NSX630 (W), 600х300; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: Schneider electric, NSX630 (W), 600х300; Тип: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: Schneider electric, NSX630 (W), 600х300
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.00183052 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 6P; DKC_Артикул ФБ_02_Установка: C; DKC_Артикул ФБ_03_Номинальный ток: 06; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: E; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 2; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: Schneider electric, NSX630 (W-MO), 600х300, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC:Schneider electric, NSX630 (W-MO), 600х300:881116
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок AB в литом корпусе (H), Schneider electric, NSX630 (W-MO), 600х300; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: Schneider electric, NSX630 (W-MO), 600х300; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 06; 05_Производитель силовых аппаратов: E; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC
Type - Размеры - ADSK_Размер_Высота: 300 mm; ADSK_Размер_Ширина: 600 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: Schneider electric, NSX630 (W-MO), 600х300
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: C - горизонтальный односторонний; 06_Номер схемного решения_1 часть: 2хх - АВ в литом корпусе; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Марка: 230
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: Schneider electric, NSX630 (W-MO), 600х300; Семейство: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: Schneider electric, NSX630 (W-MO), 600х300; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: Schneider electric, NSX630 (W-MO), 600х300; Тип: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: Schneider electric, NSX630 (W-MO), 600х300
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.00183052 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 6P; DKC_Артикул ФБ_02_Установка: C; DKC_Артикул ФБ_03_Номинальный ток: 06; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: E; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 2; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: ДКС, MD250 (F, F-MO, P, P-MO), 600х150, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC:ДКС, MD250 (F, F-MO, P, P-MO), 600х150:881285
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок AB в литом корпусе (H), ДКС, MD250 (F, F-MO, P, P-MO), 600х150; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: ДКС, MD250 (F, F-MO, P, P-MO), 600х150; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 72; 05_Производитель силовых аппаратов: Y; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC
Type - Размеры - ADSK_Размер_Высота: 150 mm; ADSK_Размер_Ширина: 600 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: ДКС, MD250 (F, F-MO, P, P-MO), 600х150
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: C - горизонтальный односторонний; 06_Номер схемного решения_1 часть: 2хх - АВ в литом корпусе; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 234
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: ДКС, MD250 (F, F-MO, P, P-MO), 600х150; Семейство: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: ДКС, MD250 (F, F-MO, P, P-MO), 600х150; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: ДКС, MD250 (F, F-MO, P, P-MO), 600х150; Тип: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: ДКС, MD250 (F, F-MO, P, P-MO), 600х150
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.0014588 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 3P; DKC_Артикул ФБ_02_Установка: C; DKC_Артикул ФБ_03_Номинальный ток: 72; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: Y; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 2; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: ДКС, MD250 (W, W-MO), 600х250, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC:ДКС, MD250 (W, W-MO), 600х250:881287
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок AB в литом корпусе (H), ДКС, MD250 (W, W-MO), 600х250; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: ДКС, MD250 (W, W-MO), 600х250; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 72; 05_Производитель силовых аппаратов: Y; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC
Type - Размеры - ADSK_Размер_Высота: 250 mm; ADSK_Размер_Ширина: 600 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: ДКС, MD250 (W, W-MO), 600х250
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: C - горизонтальный односторонний; 06_Номер схемного решения_1 часть: 2хх - АВ в литом корпусе; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Марка: 235
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: ДКС, MD250 (W, W-MO), 600х250; Семейство: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: ДКС, MD250 (W, W-MO), 600х250; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: ДКС, MD250 (W, W-MO), 600х250; Тип: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: ДКС, MD250 (W, W-MO), 600х250
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.00170661 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 5P; DKC_Артикул ФБ_02_Установка: C; DKC_Артикул ФБ_03_Номинальный ток: 72; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: Y; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 2; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: ДКС, MD630 (F, F-MO, P), 600х200, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC:ДКС, MD630 (F, F-MO, P), 600х200:881288
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок AB в литом корпусе (H), ДКС, MD630 (F, F-MO, P), 600х200; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: ДКС, MD630 (F, F-MO, P), 600х200; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 06; 05_Производитель силовых аппаратов: Y; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC
Type - Размеры - ADSK_Размер_Высота: 200 mm; ADSK_Размер_Ширина: 600 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: ДКС, MD630 (F, F-MO, P), 600х200
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: C - горизонтальный односторонний; 06_Номер схемного решения_1 часть: 2хх - АВ в литом корпусе; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 236
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: ДКС, MD630 (F, F-MO, P), 600х200; Семейство: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: ДКС, MD630 (F, F-MO, P), 600х200; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: ДКС, MD630 (F, F-MO, P), 600х200; Тип: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: ДКС, MD630 (F, F-MO, P), 600х200
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.00158271 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 4P; DKC_Артикул ФБ_02_Установка: C; DKC_Артикул ФБ_03_Номинальный ток: 06; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: Y; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 2; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: ДКС, MD630 (P-MO), 600х250, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC:ДКС, MD630 (P-MO), 600х250:881289
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок AB в литом корпусе (H), ДКС, MD630 (P-MO), 600х250; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: ДКС, MD630 (P-MO), 600х250; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 06; 05_Производитель силовых аппаратов: Y; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC
Type - Размеры - ADSK_Размер_Высота: 250 mm; ADSK_Размер_Ширина: 600 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: ДКС, MD630 (P-MO), 600х250
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: C - горизонтальный односторонний; 06_Номер схемного решения_1 часть: 2хх - АВ в литом корпусе; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 237
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: ДКС, MD630 (P-MO), 600х250; Семейство: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: ДКС, MD630 (P-MO), 600х250; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: ДКС, MD630 (P-MO), 600х250; Тип: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: ДКС, MD630 (P-MO), 600х250
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.00170661 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 5P; DKC_Артикул ФБ_02_Установка: C; DKC_Артикул ФБ_03_Номинальный ток: 06; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: Y; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 2; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: ДКС, MD630 (W), 600х300, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC:ДКС, MD630 (W), 600х300:881290
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок AB в литом корпусе (H), ДКС, MD630 (W), 600х300; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: ДКС, MD630 (W), 600х300; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 06; 05_Производитель силовых аппаратов: Y; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC
Type - Размеры - ADSK_Размер_Высота: 300 mm; ADSK_Размер_Ширина: 600 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: ДКС, MD630 (W), 600х300
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: C - горизонтальный односторонний; 06_Номер схемного решения_1 часть: 2хх - АВ в литом корпусе; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 238
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: ДКС, MD630 (W), 600х300; Семейство: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: ДКС, MD630 (W), 600х300; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: ДКС, MD630 (W), 600х300; Тип: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC: ДКС, MD630 (W), 600х300
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.00183052 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 6P; DKC_Артикул ФБ_02_Установка: C; DKC_Артикул ФБ_03_Номинальный ток: 06; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: Y; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 2; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: ДКС, MD630 (W-MO), 600х300, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_H_DKC:ДКС, MD630 (W-MO), 600х300:881291
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок AB в литом корпусе (H), ДКС, MD630 (W-MO), 600х300; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: ДКС, MD630 (W-MO), 600х300; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
