Properties of the parts of a building model (IFC2X3), part 4 of 4

# IfcBuildingElementProxy: 2200 х 800 х 1000 (400+600) (max 6300А, двухстороннее обслуживание), НВО_RAMPower_РаспределительнаяПанель_ДвойнойКаркас_DKC:2200 х 800 х 1000 (400+600) (max 6300А, двухстороннее обслуживание):672891
Прочее - IP31: no; Боковые стенки_Видимость: yes; Задняя стенка_Видимость: yes; Зона обслуживания_Видимость: yes; Кабельная колонна слева: no; Кабельная колонна справа: no; Комлект ввода_Видимость: no; Цоколь_Видимость: yes; Зона обслуживания сзади_Видимость: yes; Ручка_Видимость: yes; Код типа: НВО_RAMPower_РаспределительнаяПанель_ДвойнойКаркас_DKC: 2200 х 800 х 1000 (400+600) (max 6300А, двухстороннее обслуживание); Семейство: НВО_RAMPower_РаспределительнаяПанель_ДвойнойКаркас_DKC: 2200 х 800 х 1000 (400+600) (max 6300А, двухстороннее обслуживание); Семейство и типоразмер: НВО_RAMPower_РаспределительнаяПанель_ДвойнойКаркас_DKC: 2200 х 800 х 1000 (400+600) (max 6300А, двухстороннее обслуживание); Тип: НВО_RAMPower_РаспределительнаяПанель_ДвойнойКаркас_DKC: 2200 х 800 х 1000 (400+600) (max 6300А, двухстороннее обслуживание)
Размеры - Комплект ввода_Высота: 0 mm; Высота 2200: 50 mm; Высота стенок: 2150 mm; Объем: 10.856 m3; Площадь: 46.5515 m2; Цоколь: 100 mm; Ширина кабельной колонны: 600 mm; Ширина стенок: 960 mm
Стадии - Стадия возведения: Стадия 1
Строительство - Боковые стенки: yes; Вспомогательная надпись: yes; Задняя стенка: yes; Закрытие свободного пространства: 0; Зона обслуживания: yes; Режим установки оборудования: no; Стойки: yes
Текст - DKC_Артикул_01_Название колонны: C; DKC_Артикул_02_Номинальный ток горизонтальных сборных шин панели: 32; DKC_Артикул_03_Номинальный ток вертикальных шин: 32; DKC_Артикул_04_Ток КЗ шинной системы: G; DKC_Артикул_05_Система заземления: S; DKC_Артикул_06_Количество распределительных шин: 3; DKC_Артикул_07_Подключение: B; DKC_Артикул_08_Обслуживание: 4; DKC_Артикул_09_Высота панели: Z; DKC_Артикул_10_Ширина и глубина основной колонны: 81; DKC_Артикул_11_Ширина кабельной колонны (при одностороннем обслуж): 0; DKC_Артикул_12_Секционирование: 3b
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: 2200 х 800 х 1000 (400+600) (max 6300А, одностороннее обслуживание), НВО_RAMPower_РаспределительнаяПанель_ДвойнойКаркас_DKC:2200 х 800 х 1000 (400+600) (max 6300А, одностороннее обслуживание):672881
In: Этаж 01
Type - Material: DKC_Красный_Лого, DKC_Металл_Светлый, DKC_Металл_Серый, DKC_Зона обслуживания
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Распределительная панель, двойной каркас, 2200 х 800 х 1000 (400+600) (max 6300А, одностороннее обслуживание); ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2; DKC_Ударопрочность: IK10
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: 2200 х 800 х 1000 (400+600) (max 6300А, одностороннее обслуживание); Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 01_Название колонны_A: A - Панель для воздушных выключателей; 01_Название колонны_C: С - Панель комбинированная; 01_Название колонны_M: M - Панель управления электродвигателями; 02_Номинальный ток горизонтальных сборных шин панели_00: 00 - без сборных шин; 02_Номинальный ток горизонтальных сборных шин панели_06: 06 = 630 А; 02_Номинальный ток горизонтальных сборных шин панели_08: 08 = 800 А; 02_Номинальный ток горизонтальных сборных шин панели_10: 10 = 1000 А; 02_Номинальный ток горизонтальных сборных шин панели_12: 12 = 1250 А; 02_Номинальный ток горизонтальных сборных шин панели_16: 16 = 1600 А; 02_Номинальный ток горизонтальных сборных шин панели_20: 20 = 2000 А; 02_Номинальный ток горизонтальных сборных шин панели_25: 25 = 2500 А; 02_Номинальный ток горизонтальных сборных шин панели_32: 32 = 3200 А; 02_Номинальный ток горизонтальных сборных шин панели_40: 40 = 4000 А; 02_Номинальный ток горизонтальных сборных шин панели_50: 50 = 5000 А; 02_Номинальный ток горизонтальных сборных шин панели_63: 63 = 6300 А; 03_Номинальный ток вертикальных шин_00: 00 - без сборных шин; 03_Номинальный ток вертикальных шин_06: 06 = 630 А; 03_Номинальный ток вертикальных шин_08: 08 = 800 А; 03_Номинальный ток вертикальных шин_10: 10 = 1000 А; 03_Номинальный ток вертикальных шин_12: 12 = 1250 А; 03_Номинальный ток вертикальных шин_16: 16 = 1600 А; 03_Номинальный ток вертикальных шин_20: 20 = 2000 А; 03_Номинальный ток вертикальных шин_25: 25 = 2500 А; 03_Номинальный ток вертикальных шин_32: 32 = 3200 А; 03_Номинальный ток вертикальных шин_40: 40 = 4000 А; 03_Номинальный ток вертикальных шин_50: 50 = 5000 А; 03_Номинальный ток вертикальных шин_63: 63 = 6300 А; 04_Ток КЗ шинной системы_A: A= 25; 04_Ток КЗ шинной системы_B: B = 36; 04_Ток КЗ шинной системы_C: C = 50; 04_Ток КЗ шинной системы_D: D = 65; 04_Ток КЗ шинной системы_E: E = 75; 04_Ток КЗ шинной системы_F: F = 85; 04_Ток КЗ шинной системы_G: G = 100; 05_Система заземления_C: C = TN-C; 05_Система заземления_D: D = TN-C-S; 05_Система заземления_I: I = IT; 05_Система заземления_S: S = TN-S; 05_Система заземления_T: T = TT; 06_Количество распределительных шин_3: 3 – полюса; 06_Количество распределительных шин_4: 4 – полюса; 07_Подключение_A: A - верхнее шинопроводом; 07_Подключение_B: B - верхнее кабелем; 07_Подключение_C: C - нижнее кабелем; 07_Подключение_D: D - боковое левое шинами; 07_Подключение_E: E - боковое правое шинами; 07_Подключение_Х: Х - без внешних силовых подключений; 08_Обслуживание_IP31: 1/2 - IP31; 08_Обслуживание_IP54: 3/4 - IP54; 09_Высота панели_Без цоколя: Без цоколя; 09_Высота панели_С цоколем: С цоколем; 11_Ширина кабельной колонны (при одностороннем обслуж)_0: 0 - отсутствует; 11_Ширина кабельной колонны (при одностороннем обслуж)_4 слева: 4 - 400 слева; 11_Ширина кабельной колонны (при одностороннем обслуж)_4 справа: 4 - 400 справа; 11_Ширина кабельной колонны (при одностороннем обслуж)_6 слева: 6 - 600 слева; 11_Ширина кабельной колонны (при одностороннем обслуж)_6 справа: 6 - 600 справа; 12_Секционирование_1a: 1a - без секционирования; 12_Секционирование_2a: 2a - секционирование; 12_Секционирование_2b: 2b - секционирование; 12_Секционирование_3a: 3a - секционирование; 12_Секционирование_3b: 3b - секционирование; 12_Секционирование_4a: 4a - секционирование; 12_Секционирование_4b: 4b - секционирование; Обслуживание: 1; Имя семейства: НВО_RAMPower_РаспределительнаяПанель_ДвойнойКаркас_DKC
Type - Размеры - ADSK_Размер_Высота: 2200 mm; ADSK_Размер_Глубина: 1000 mm; ADSK_Размер_Ширина: 800 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: 2200 х 800 х 1000 (400+600) (max 6300А, одностороннее обслуживание)
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 01_Название колонны: С - Панель комбинированная; 02_Номинальный ток горизонтальных сборных шин панели: 32 = 3200 А; 03_Номинальный ток вертикальных шин: 32 = 3200 А; 04_Ток КЗ шинной системы: G = 100; 05_Система заземления: S = TN-S; 06_Количество распределительных шин: 3 – полюса; 07_Подключение: B - верхнее кабелем; 08_Обслуживание: 3/4 - IP54; 09_Высота панели: С цоколем; 11_Ширина кабельной колонны (при одностороннем обслуж): 0 - отсутствует; 12_Секционирование: 3b - секционирование
Зависимости - Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 44
Прочее - IP31: no; Боковые стенки_Видимость: yes; Задняя стенка_Видимость: yes; Зона обслуживания_Видимость: yes; Зона обслуживания сзади_Видимость: no; Кабельная колонна слева: no; Кабельная колонна справа: no; Комлект ввода_Видимость: no; Ручка_Видимость: no; Цоколь_Видимость: yes; Код типа: НВО_RAMPower_РаспределительнаяПанель_ДвойнойКаркас_DKC: 2200 х 800 х 1000 (400+600) (max 6300А, одностороннее обслуживание); Семейство: НВО_RAMPower_РаспределительнаяПанель_ДвойнойКаркас_DKC: 2200 х 800 х 1000 (400+600) (max 6300А, одностороннее обслуживание); Семейство и типоразмер: НВО_RAMPower_РаспределительнаяПанель_ДвойнойКаркас_DKC: 2200 х 800 х 1000 (400+600) (max 6300А, одностороннее обслуживание); Тип: НВО_RAMPower_РаспределительнаяПанель_ДвойнойКаркас_DKC: 2200 х 800 х 1000 (400+600) (max 6300А, одностороннее обслуживание)
Размеры - Комплект ввода_Высота: 0 mm; Высота 2200: 50 mm; Высота стенок: 2150 mm; Объем: 7.728 m3; Площадь: 46.5515 m2; Цоколь: 100 mm; Ширина кабельной колонны: 600 mm; Ширина стенок: 960 mm
Стадии - Стадия возведения: Стадия 1
Строительство - Боковые стенки: yes; Вспомогательная надпись: yes; Задняя стенка: yes; Закрытие свободного пространства: 0; Зона обслуживания: yes; Режим установки оборудования: no; Стойки: yes
Текст - DKC_Артикул_01_Название колонны: C; DKC_Артикул_02_Номинальный ток горизонтальных сборных шин панели: 32; DKC_Артикул_03_Номинальный ток вертикальных шин: 32; DKC_Артикул_04_Ток КЗ шинной системы: G; DKC_Артикул_05_Система заземления: S; DKC_Артикул_06_Количество распределительных шин: 3; DKC_Артикул_07_Подключение: B; DKC_Артикул_08_Обслуживание: 3; DKC_Артикул_09_Высота панели: Z; DKC_Артикул_10_Ширина и глубина основной колонны: 81; DKC_Артикул_11_Ширина кабельной колонны (при одностороннем обслуж): 0; DKC_Артикул_12_Секционирование: 3b
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: 2200 х 800 х 1200 (400+800) (max 6300А, двухстороннее обслуживание), НВО_RAMPower_РаспределительнаяПанель_ДвойнойКаркас_DKC:2200 х 800 х 1200 (400+800) (max 6300А, двухстороннее обслуживание):672883
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Красный_Лого, DKC_Металл_Светлый, DKC_Зона обслуживания
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Распределительная панель, двойной каркас, 2200 х 800 х 1200 (400+800) (max 6300А, двухстороннее обслуживание); ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2; DKC_Ударопрочность: IK10
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: 2200 х 800 х 1200 (400+800) (max 6300А, двухстороннее обслуживание); Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 01_Название колонны_A: A - Панель для воздушных выключателей; 01_Название колонны_C: С - Панель комбинированная; 01_Название колонны_M: M - Панель управления электродвигателями; 02_Номинальный ток горизонтальных сборных шин панели_00: 00 - без сборных шин; 02_Номинальный ток горизонтальных сборных шин панели_06: 06 = 630 А; 02_Номинальный ток горизонтальных сборных шин панели_08: 08 = 800 А; 02_Номинальный ток горизонтальных сборных шин панели_10: 10 = 1000 А; 02_Номинальный ток горизонтальных сборных шин панели_12: 12 = 1250 А; 02_Номинальный ток горизонтальных сборных шин панели_16: 16 = 1600 А; 02_Номинальный ток горизонтальных сборных шин панели_20: 20 = 2000 А; 02_Номинальный ток горизонтальных сборных шин панели_25: 25 = 2500 А; 02_Номинальный ток горизонтальных сборных шин панели_32: 32 = 3200 А; 02_Номинальный ток горизонтальных сборных шин панели_40: 40 = 4000 А; 02_Номинальный ток горизонтальных сборных шин панели_50: 50 = 5000 А; 02_Номинальный ток горизонтальных сборных шин панели_63: 63 = 6300 А; 03_Номинальный ток вертикальных шин_00: 00 - без сборных шин; 03_Номинальный ток вертикальных шин_06: 06 = 630 А; 03_Номинальный ток вертикальных шин_08: 08 = 800 А; 03_Номинальный ток вертикальных шин_10: 10 = 1000 А; 03_Номинальный ток вертикальных шин_12: 12 = 1250 А; 03_Номинальный ток вертикальных шин_16: 16 = 1600 А; 03_Номинальный ток вертикальных шин_20: 20 = 2000 А; 03_Номинальный ток вертикальных шин_25: 25 = 2500 А; 03_Номинальный ток вертикальных шин_32: 32 = 3200 А; 03_Номинальный ток вертикальных шин_40: 40 = 4000 А; 03_Номинальный ток вертикальных шин_50: 50 = 5000 А; 03_Номинальный ток вертикальных шин_63: 63 = 6300 А; 04_Ток КЗ шинной системы_A: A= 25; 04_Ток КЗ шинной системы_B: B = 36; 04_Ток КЗ шинной системы_C: C = 50; 04_Ток КЗ шинной системы_D: D = 65; 04_Ток КЗ шинной системы_E: E = 75; 04_Ток КЗ шинной системы_F: F = 85; 04_Ток КЗ шинной системы_G: G = 100; 05_Система заземления_C: C = TN-C; 05_Система заземления_D: D = TN-C-S; 05_Система заземления_I: I = IT; 05_Система заземления_S: S = TN-S; 05_Система заземления_T: T = TT; 06_Количество распределительных шин_3: 3 – полюса; 06_Количество распределительных шин_4: 4 – полюса; 07_Подключение_A: A - верхнее шинопроводом; 07_Подключение_B: B - верхнее кабелем; 07_Подключение_C: C - нижнее кабелем; 07_Подключение_D: D - боковое левое шинами; 07_Подключение_E: E - боковое правое шинами; 07_Подключение_Х: Х - без внешних силовых подключений; 08_Обслуживание_IP31: 1/2 - IP31; 08_Обслуживание_IP54: 3/4 - IP54; 09_Высота панели_Без цоколя: Без цоколя; 09_Высота панели_С цоколем: С цоколем; 11_Ширина кабельной колонны (при одностороннем обслуж)_0: 0 - отсутствует; 11_Ширина кабельной колонны (при одностороннем обслуж)_4 слева: 4 - 400 слева; 11_Ширина кабельной колонны (при одностороннем обслуж)_4 справа: 4 - 400 справа; 11_Ширина кабельной колонны (при одностороннем обслуж)_6 слева: 6 - 600 слева; 11_Ширина кабельной колонны (при одностороннем обслуж)_6 справа: 6 - 600 справа; 12_Секционирование_1a: 1a - без секционирования; 12_Секционирование_2a: 2a - секционирование; 12_Секционирование_2b: 2b - секционирование; 12_Секционирование_3a: 3a - секционирование; 12_Секционирование_3b: 3b - секционирование; 12_Секционирование_4a: 4a - секционирование; 12_Секционирование_4b: 4b - секционирование; Обслуживание: 2; Имя семейства: НВО_RAMPower_РаспределительнаяПанель_ДвойнойКаркас_DKC
Type - Размеры - ADSK_Размер_Высота: 2200 mm; ADSK_Размер_Глубина: 1200 mm; ADSK_Размер_Ширина: 800 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: 2200 х 800 х 1200 (400+800) (max 6300А, двухстороннее обслуживание)
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 01_Название колонны: С - Панель комбинированная; 02_Номинальный ток горизонтальных сборных шин панели: 32 = 3200 А; 03_Номинальный ток вертикальных шин: 32 = 3200 А; 04_Ток КЗ шинной системы: G = 100; 05_Система заземления: S = TN-S; 06_Количество распределительных шин: 3 – полюса; 07_Подключение: B - верхнее кабелем; 08_Обслуживание: 3/4 - IP54; 09_Высота панели: С цоколем; 11_Ширина кабельной колонны (при одностороннем обслуж): 0 - отсутствует; 12_Секционирование: 3b - секционирование
Зависимости - Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Марка: 46
Прочее - IP31: no; Боковые стенки_Видимость: yes; Задняя стенка_Видимость: yes; Зона обслуживания_Видимость: yes; Кабельная колонна слева: no; Кабельная колонна справа: no; Комлект ввода_Видимость: no; Цоколь_Видимость: yes; Зона обслуживания сзади_Видимость: yes; Ручка_Видимость: yes; Код типа: НВО_RAMPower_РаспределительнаяПанель_ДвойнойКаркас_DKC: 2200 х 800 х 1200 (400+800) (max 6300А, двухстороннее обслуживание); Семейство: НВО_RAMPower_РаспределительнаяПанель_ДвойнойКаркас_DKC: 2200 х 800 х 1200 (400+800) (max 6300А, двухстороннее обслуживание); Семейство и типоразмер: НВО_RAMPower_РаспределительнаяПанель_ДвойнойКаркас_DKC: 2200 х 800 х 1200 (400+800) (max 6300А, двухстороннее обслуживание); Тип: НВО_RAMPower_РаспределительнаяПанель_ДвойнойКаркас_DKC: 2200 х 800 х 1200 (400+800) (max 6300А, двухстороннее обслуживание)
Размеры - Комплект ввода_Высота: 0 mm; Высота 2200: 50 mm; Высота стенок: 2150 mm; Объем: 11.776 m3; Площадь: 49.9981 m2; Цоколь: 100 mm; Ширина кабельной колонны: 600 mm; Ширина стенок: 1160 mm
Стадии - Стадия возведения: Стадия 1
Строительство - Боковые стенки: yes; Вспомогательная надпись: yes; Задняя стенка: yes; Закрытие свободного пространства: 0; Зона обслуживания: yes; Режим установки оборудования: no; Стойки: yes
Текст - DKC_Артикул_01_Название колонны: C; DKC_Артикул_02_Номинальный ток горизонтальных сборных шин панели: 32; DKC_Артикул_03_Номинальный ток вертикальных шин: 32; DKC_Артикул_04_Ток КЗ шинной системы: G; DKC_Артикул_05_Система заземления: S; DKC_Артикул_06_Количество распределительных шин: 3; DKC_Артикул_07_Подключение: B; DKC_Артикул_08_Обслуживание: 4; DKC_Артикул_09_Высота панели: Z; DKC_Артикул_10_Ширина и глубина основной колонны: 82; DKC_Артикул_11_Ширина кабельной колонны (при одностороннем обслуж): 0; DKC_Артикул_12_Секционирование: 3b
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: 2200 х 800 х 1200 (400+800) (max 6300А, одностороннее обслуживание), НВО_RAMPower_РаспределительнаяПанель_ДвойнойКаркас_DKC:2200 х 800 х 1200 (400+800) (max 6300А, одностороннее обслуживание):672882
In: Этаж 01
Type - Material: DKC_Красный_Лого, DKC_Металл_Светлый, DKC_Металл_Серый, DKC_Зона обслуживания
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Распределительная панель, двойной каркас, 2200 х 800 х 1200 (400+800) (max 6300А, одностороннее обслуживание); ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2; DKC_Ударопрочность: IK10
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: 2200 х 800 х 1200 (400+800) (max 6300А, одностороннее обслуживание); Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 01_Название колонны_A: A - Панель для воздушных выключателей; 01_Название колонны_C: С - Панель комбинированная; 01_Название колонны_M: M - Панель управления электродвигателями; 02_Номинальный ток горизонтальных сборных шин панели_00: 00 - без сборных шин; 02_Номинальный ток горизонтальных сборных шин панели_06: 06 = 630 А; 02_Номинальный ток горизонтальных сборных шин панели_08: 08 = 800 А; 02_Номинальный ток горизонтальных сборных шин панели_10: 10 = 1000 А; 02_Номинальный ток горизонтальных сборных шин панели_12: 12 = 1250 А; 02_Номинальный ток горизонтальных сборных шин панели_16: 16 = 1600 А; 02_Номинальный ток горизонтальных сборных шин панели_20: 20 = 2000 А; 02_Номинальный ток горизонтальных сборных шин панели_25: 25 = 2500 А; 02_Номинальный ток горизонтальных сборных шин панели_32: 32 = 3200 А; 02_Номинальный ток горизонтальных сборных шин панели_40: 40 = 4000 А; 02_Номинальный ток горизонтальных сборных шин панели_50: 50 = 5000 А; 02_Номинальный ток горизонтальных сборных шин панели_63: 63 = 6300 А; 03_Номинальный ток вертикальных шин_00: 00 - без сборных шин; 03_Номинальный ток вертикальных шин_06: 06 = 630 А; 03_Номинальный ток вертикальных шин_08: 08 = 800 А; 03_Номинальный ток вертикальных шин_10: 10 = 1000 А; 03_Номинальный ток вертикальных шин_12: 12 = 1250 А; 03_Номинальный ток вертикальных шин_16: 16 = 1600 А; 03_Номинальный ток вертикальных шин_20: 20 = 2000 А; 03_Номинальный ток вертикальных шин_25: 25 = 2500 А; 03_Номинальный ток вертикальных шин_32: 32 = 3200 А; 03_Номинальный ток вертикальных шин_40: 40 = 4000 А; 03_Номинальный ток вертикальных шин_50: 50 = 5000 А; 03_Номинальный ток вертикальных шин_63: 63 = 6300 А; 04_Ток КЗ шинной системы_A: A= 25; 04_Ток КЗ шинной системы_B: B = 36; 04_Ток КЗ шинной системы_C: C = 50; 04_Ток КЗ шинной системы_D: D = 65; 04_Ток КЗ шинной системы_E: E = 75; 04_Ток КЗ шинной системы_F: F = 85; 04_Ток КЗ шинной системы_G: G = 100; 05_Система заземления_C: C = TN-C; 05_Система заземления_D: D = TN-C-S; 05_Система заземления_I: I = IT; 05_Система заземления_S: S = TN-S; 05_Система заземления_T: T = TT; 06_Количество распределительных шин_3: 3 – полюса; 06_Количество распределительных шин_4: 4 – полюса; 07_Подключение_A: A - верхнее шинопроводом; 07_Подключение_B: B - верхнее кабелем; 07_Подключение_C: C - нижнее кабелем; 07_Подключение_D: D - боковое левое шинами; 07_Подключение_E: E - боковое правое шинами; 07_Подключение_Х: Х - без внешних силовых подключений; 08_Обслуживание_IP31: 1/2 - IP31; 08_Обслуживание_IP54: 3/4 - IP54; 09_Высота панели_Без цоколя: Без цоколя; 09_Высота панели_С цоколем: С цоколем; 11_Ширина кабельной колонны (при одностороннем обслуж)_0: 0 - отсутствует; 11_Ширина кабельной колонны (при одностороннем обслуж)_4 слева: 4 - 400 слева; 11_Ширина кабельной колонны (при одностороннем обслуж)_4 справа: 4 - 400 справа; 11_Ширина кабельной колонны (при одностороннем обслуж)_6 слева: 6 - 600 слева; 11_Ширина кабельной колонны (при одностороннем обслуж)_6 справа: 6 - 600 справа; 12_Секционирование_1a: 1a - без секционирования; 12_Секционирование_2a: 2a - секционирование; 12_Секционирование_2b: 2b - секционирование; 12_Секционирование_3a: 3a - секционирование; 12_Секционирование_3b: 3b - секционирование; 12_Секционирование_4a: 4a - секционирование; 12_Секционирование_4b: 4b - секционирование; Обслуживание: 1; Имя семейства: НВО_RAMPower_РаспределительнаяПанель_ДвойнойКаркас_DKC
Type - Размеры - ADSK_Размер_Высота: 2200 mm; ADSK_Размер_Глубина: 1200 mm; ADSK_Размер_Ширина: 800 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: 2200 х 800 х 1200 (400+800) (max 6300А, одностороннее обслуживание)
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 01_Название колонны: С - Панель комбинированная; 02_Номинальный ток горизонтальных сборных шин панели: 32 = 3200 А; 03_Номинальный ток вертикальных шин: 32 = 3200 А; 04_Ток КЗ шинной системы: G = 100; 05_Система заземления: S = TN-S; 06_Количество распределительных шин: 3 – полюса; 07_Подключение: B - верхнее кабелем; 08_Обслуживание: 3/4 - IP54; 09_Высота панели: С цоколем; 11_Ширина кабельной колонны (при одностороннем обслуж): 0 - отсутствует; 12_Секционирование: 3b - секционирование
Зависимости - Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 45
Прочее - IP31: no; Боковые стенки_Видимость: yes; Задняя стенка_Видимость: yes; Зона обслуживания_Видимость: yes; Зона обслуживания сзади_Видимость: no; Кабельная колонна слева: no; Кабельная колонна справа: no; Комлект ввода_Видимость: no; Ручка_Видимость: no; Цоколь_Видимость: yes; Код типа: НВО_RAMPower_РаспределительнаяПанель_ДвойнойКаркас_DKC: 2200 х 800 х 1200 (400+800) (max 6300А, одностороннее обслуживание); Семейство: НВО_RAMPower_РаспределительнаяПанель_ДвойнойКаркас_DKC: 2200 х 800 х 1200 (400+800) (max 6300А, одностороннее обслуживание); Семейство и типоразмер: НВО_RAMPower_РаспределительнаяПанель_ДвойнойКаркас_DKC: 2200 х 800 х 1200 (400+800) (max 6300А, одностороннее обслуживание); Тип: НВО_RAMPower_РаспределительнаяПанель_ДвойнойКаркас_DKC: 2200 х 800 х 1200 (400+800) (max 6300А, одностороннее обслуживание)
Размеры - Комплект ввода_Высота: 0 mm; Высота 2200: 50 mm; Высота стенок: 2150 mm; Объем: 8.648 m3; Площадь: 49.9981 m2; Цоколь: 100 mm; Ширина кабельной колонны: 600 mm; Ширина стенок: 1160 mm
Стадии - Стадия возведения: Стадия 1
Строительство - Боковые стенки: yes; Вспомогательная надпись: yes; Задняя стенка: yes; Закрытие свободного пространства: 0; Зона обслуживания: yes; Режим установки оборудования: no; Стойки: yes
Текст - DKC_Артикул_01_Название колонны: C; DKC_Артикул_02_Номинальный ток горизонтальных сборных шин панели: 32; DKC_Артикул_03_Номинальный ток вертикальных шин: 32; DKC_Артикул_04_Ток КЗ шинной системы: G; DKC_Артикул_05_Система заземления: S; DKC_Артикул_06_Количество распределительных шин: 3; DKC_Артикул_07_Подключение: B; DKC_Артикул_08_Обслуживание: 3; DKC_Артикул_09_Высота панели: Z; DKC_Артикул_10_Ширина и глубина основной колонны: 82; DKC_Артикул_11_Ширина кабельной колонны (при одностороннем обслуж): 0; DKC_Артикул_12_Секционирование: 3b
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: Текст модели:300 (4)
In: Этаж 01
Текст(Type) - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Прочее(Type) - Категория: Обобщенные модели; Имя семейства: Текст модели
Идентификация(Type) - Имя типа: 300
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: По центру
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели
Материалы и отделка - Материал: DKC_Серый_Лого
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Name (Текст модели:...) | Текст | Вариант конструкции
300 | Одностороннее обслуживание | Оформление каталога : Оформление каталога
300 | Двухстороннее обслуживание | Оформление каталога (основной)
300 | Одностороннее обслуживание | Оформление каталога (основной)
300 | Двухстороннее обслуживание | Оформление каталога : Оформление каталога
