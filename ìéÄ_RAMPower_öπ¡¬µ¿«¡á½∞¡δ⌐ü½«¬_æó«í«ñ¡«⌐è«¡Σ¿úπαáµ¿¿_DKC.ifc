Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2022-10-07T01:44:21
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181217_1515(x64) - Exporter 19.2.0.65 - Альтернативный интерфейс 19.2.0.65
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Oct 07 01:44:21 2022 * Host: SERGEY_MIKHALEV * Database: C:\Users\mkhlv\AppData\Local\Temp\{289A2BC9-4BC9-4C5B-95EF-A2F1A7F44D23}\ifc * Database version: 5507 * Database creation date: Fri Oct 07 01:44:21 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Oct 07 01:44:21 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Oct 07 01:44:21 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2022
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2022
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее(Type) - Категория: Уровни; Имя семейства: Уровень
Идентификация(Type) - Имя типа: Отметка уровня с именем
Зависимости(Type) - Базовая отметка: Базовая точка проекта
Графика(Type) - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Зависимости - Фасад: 0 mm
Идентификация - Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Прочее - Категория: Уровни; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Размеры - Расчетная высота: 0 mm

# IfcBuildingElementProxy: 600 х 150, НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC:600 х 150:833678
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Наименование: Блок свободной конфигурации, 600 х 150; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: 600 х 150; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 03_Номинальный ток_01: 01 = 70-125А; 03_Номинальный ток_02: 02 = 165-200А; 03_Номинальный ток_03: 03 = 260-320 (315)A; 03_Номинальный ток_04: 04 = 330-400A; 03_Номинальный ток_06: 06 = 420-630А; 03_Номинальный ток_08: 08 = 650- 800А; 03_Номинальный ток_10: 10 = 850-1000А; 03_Номинальный ток_12: 12 = 1100-1250А; 03_Номинальный ток_16: 16 = 1300-1600А; 03_Номинальный ток_20: 20 = 1700- 2000А; 03_Номинальный ток_25: 25 = 2100- 2500А; 03_Номинальный ток_32: 32 = 2600-3200А; 03_Номинальный ток_40: 40 = 3500-4000А; 03_Номинальный ток_50: 50 = 4100- 5000А; 03_Номинальный ток_63: 63 = 5100- 6300А; 03_Номинальный ток_70: 70 = 1-63А; 03_Номинальный ток_71: 71 = 130-160; 03_Номинальный ток_72: 72 = 210-250А; 04_Количество полюсов выключателя_1: 1 – полюс; 04_Количество полюсов выключателя_2: 2 – полюса; 04_Количество полюсов выключателя_3: 3 – полюса; 04_Количество полюсов выключателя_4: 4 – полюса; 05_Производитель силовых аппаратов_0: 0 - прочее оборудование; 05_Производитель силовых аппаратов_E: E - Schneider electric; 05_Производитель силовых аппаратов_H: H - Hyundai; 05_Производитель силовых аппаратов_I: I - Siemens; 05_Производитель силовых аппаратов_K: K - КЭАЗ; 05_Производитель силовых аппаратов_L: L - LSIS electric; 05_Производитель силовых аппаратов_Y: Y - ДКС; 05_Производитель силовых аппаратов_А: А - АBB; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_1: 1хх - модульный АВ; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_3: 3хх - воздушный АВ; 06_Номер схемного решения_1 часть_4: 4хх - выключатель - разъединитель; 06_Номер схемного решения_1 часть_5: 5хх - АВ защиты двигателя; 06_Номер схемного решения_1 часть_6: 6xx - модульный АВ с пускорегулятором; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_8: 8xx - АВ защиты двигателя с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; Имя семейства: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC
Type - Размеры - ADSK_Размер_Высота: 150 mm; ADSK_Размер_Ширина: 600 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: 600 х 150
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 03_Номинальный ток: 72 = 210-250А; 04_Количество полюсов выключателя: 3 – полюса; 05_Производитель силовых аппаратов: Y - ДКС; 06_Номер схемного решения_1 часть: 0xx - общесекционное устройство; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Рабочая плоскость: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Марка: 98
Прочее - 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Код типа: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC: 600 х 150; Семейство: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC: 600 х 150; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC: 600 х 150; Тип: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC: 600 х 150; Уровень спецификации: Уровень: Этаж 01
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.0004588 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 3P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 72; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: Y; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 0; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Усредненный коэффициент спроса: 1; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: 600 х 200, НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC:600 х 200:833956
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Блок свободной конфигурации, 600 х 200; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: 600 х 200; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 03_Номинальный ток_01: 01 = 70-125А; 03_Номинальный ток_02: 02 = 165-200А; 03_Номинальный ток_03: 03 = 260-320 (315)A; 03_Номинальный ток_04: 04 = 330-400A; 03_Номинальный ток_06: 06 = 420-630А; 03_Номинальный ток_08: 08 = 650- 800А; 03_Номинальный ток_10: 10 = 850-1000А; 03_Номинальный ток_12: 12 = 1100-1250А; 03_Номинальный ток_16: 16 = 1300-1600А; 03_Номинальный ток_20: 20 = 1700- 2000А; 03_Номинальный ток_25: 25 = 2100- 2500А; 03_Номинальный ток_32: 32 = 2600-3200А; 03_Номинальный ток_40: 40 = 3500-4000А; 03_Номинальный ток_50: 50 = 4100- 5000А; 03_Номинальный ток_63: 63 = 5100- 6300А; 03_Номинальный ток_70: 70 = 1-63А; 03_Номинальный ток_71: 71 = 130-160; 03_Номинальный ток_72: 72 = 210-250А; 04_Количество полюсов выключателя_1: 1 – полюс; 04_Количество полюсов выключателя_2: 2 – полюса; 04_Количество полюсов выключателя_3: 3 – полюса; 04_Количество полюсов выключателя_4: 4 – полюса; 05_Производитель силовых аппаратов_0: 0 - прочее оборудование; 05_Производитель силовых аппаратов_E: E - Schneider electric; 05_Производитель силовых аппаратов_H: H - Hyundai; 05_Производитель силовых аппаратов_I: I - Siemens; 05_Производитель силовых аппаратов_K: K - КЭАЗ; 05_Производитель силовых аппаратов_L: L - LSIS electric; 05_Производитель силовых аппаратов_Y: Y - ДКС; 05_Производитель силовых аппаратов_А: А - АBB; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_1: 1хх - модульный АВ; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_3: 3хх - воздушный АВ; 06_Номер схемного решения_1 часть_4: 4хх - выключатель - разъединитель; 06_Номер схемного решения_1 часть_5: 5хх - АВ защиты двигателя; 06_Номер схемного решения_1 часть_6: 6xx - модульный АВ с пускорегулятором; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_8: 8xx - АВ защиты двигателя с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; Имя семейства: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC
Type - Размеры - ADSK_Размер_Высота: 200 mm; ADSK_Размер_Ширина: 600 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: 600 х 200
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 03_Номинальный ток: 72 = 210-250А; 04_Количество полюсов выключателя: 3 – полюса; 05_Производитель силовых аппаратов: Y - ДКС; 06_Номер схемного решения_1 часть: 0xx - общесекционное устройство; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Марка: 99
Прочее - 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC: 600 х 200; Семейство: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC: 600 х 200; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC: 600 х 200; Тип: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC: 600 х 200
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.000582705 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 4P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 72; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: Y; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 0; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: 600 х 250, НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC:600 х 250:833976
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Блок свободной конфигурации, 600 х 250; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: 600 х 250; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 03_Номинальный ток_01: 01 = 70-125А; 03_Номинальный ток_02: 02 = 165-200А; 03_Номинальный ток_03: 03 = 260-320 (315)A; 03_Номинальный ток_04: 04 = 330-400A; 03_Номинальный ток_06: 06 = 420-630А; 03_Номинальный ток_08: 08 = 650- 800А; 03_Номинальный ток_10: 10 = 850-1000А; 03_Номинальный ток_12: 12 = 1100-1250А; 03_Номинальный ток_16: 16 = 1300-1600А; 03_Номинальный ток_20: 20 = 1700- 2000А; 03_Номинальный ток_25: 25 = 2100- 2500А; 03_Номинальный ток_32: 32 = 2600-3200А; 03_Номинальный ток_40: 40 = 3500-4000А; 03_Номинальный ток_50: 50 = 4100- 5000А; 03_Номинальный ток_63: 63 = 5100- 6300А; 03_Номинальный ток_70: 70 = 1-63А; 03_Номинальный ток_71: 71 = 130-160; 03_Номинальный ток_72: 72 = 210-250А; 04_Количество полюсов выключателя_1: 1 – полюс; 04_Количество полюсов выключателя_2: 2 – полюса; 04_Количество полюсов выключателя_3: 3 – полюса; 04_Количество полюсов выключателя_4: 4 – полюса; 05_Производитель силовых аппаратов_0: 0 - прочее оборудование; 05_Производитель силовых аппаратов_E: E - Schneider electric; 05_Производитель силовых аппаратов_H: H - Hyundai; 05_Производитель силовых аппаратов_I: I - Siemens; 05_Производитель силовых аппаратов_K: K - КЭАЗ; 05_Производитель силовых аппаратов_L: L - LSIS electric; 05_Производитель силовых аппаратов_Y: Y - ДКС; 05_Производитель силовых аппаратов_А: А - АBB; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_1: 1хх - модульный АВ; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_3: 3хх - воздушный АВ; 06_Номер схемного решения_1 часть_4: 4хх - выключатель - разъединитель; 06_Номер схемного решения_1 часть_5: 5хх - АВ защиты двигателя; 06_Номер схемного решения_1 часть_6: 6xx - модульный АВ с пускорегулятором; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_8: 8xx - АВ защиты двигателя с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; Имя семейства: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC
Type - Размеры - ADSK_Размер_Высота: 250 mm; ADSK_Размер_Ширина: 600 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: 600 х 250
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 03_Номинальный ток: 72 = 210-250А; 04_Количество полюсов выключателя: 3 – полюса; 05_Производитель силовых аппаратов: Y - ДКС; 06_Номер схемного решения_1 часть: 0xx - общесекционное устройство; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Марка: 100
Прочее - 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC: 600 х 250; Семейство: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC: 600 х 250; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC: 600 х 250; Тип: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC: 600 х 250
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.000706611 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 5P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 72; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: Y; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 0; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: 600 х 300, НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC:600 х 300:833979
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Блок свободной конфигурации, 600 х 300; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: 600 х 300; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 03_Номинальный ток_01: 01 = 70-125А; 03_Номинальный ток_02: 02 = 165-200А; 03_Номинальный ток_03: 03 = 260-320 (315)A; 03_Номинальный ток_04: 04 = 330-400A; 03_Номинальный ток_06: 06 = 420-630А; 03_Номинальный ток_08: 08 = 650- 800А; 03_Номинальный ток_10: 10 = 850-1000А; 03_Номинальный ток_12: 12 = 1100-1250А; 03_Номинальный ток_16: 16 = 1300-1600А; 03_Номинальный ток_20: 20 = 1700- 2000А; 03_Номинальный ток_25: 25 = 2100- 2500А; 03_Номинальный ток_32: 32 = 2600-3200А; 03_Номинальный ток_40: 40 = 3500-4000А; 03_Номинальный ток_50: 50 = 4100- 5000А; 03_Номинальный ток_63: 63 = 5100- 6300А; 03_Номинальный ток_70: 70 = 1-63А; 03_Номинальный ток_71: 71 = 130-160; 03_Номинальный ток_72: 72 = 210-250А; 04_Количество полюсов выключателя_1: 1 – полюс; 04_Количество полюсов выключателя_2: 2 – полюса; 04_Количество полюсов выключателя_3: 3 – полюса; 04_Количество полюсов выключателя_4: 4 – полюса; 05_Производитель силовых аппаратов_0: 0 - прочее оборудование; 05_Производитель силовых аппаратов_E: E - Schneider electric; 05_Производитель силовых аппаратов_H: H - Hyundai; 05_Производитель силовых аппаратов_I: I - Siemens; 05_Производитель силовых аппаратов_K: K - КЭАЗ; 05_Производитель силовых аппаратов_L: L - LSIS electric; 05_Производитель силовых аппаратов_Y: Y - ДКС; 05_Производитель силовых аппаратов_А: А - АBB; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_1: 1хх - модульный АВ; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_3: 3хх - воздушный АВ; 06_Номер схемного решения_1 часть_4: 4хх - выключатель - разъединитель; 06_Номер схемного решения_1 часть_5: 5хх - АВ защиты двигателя; 06_Номер схемного решения_1 часть_6: 6xx - модульный АВ с пускорегулятором; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_8: 8xx - АВ защиты двигателя с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; Имя семейства: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC
Type - Размеры - ADSK_Размер_Высота: 300 mm; ADSK_Размер_Ширина: 600 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: 600 х 300
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 03_Номинальный ток: 72 = 210-250А; 04_Количество полюсов выключателя: 3 – полюса; 05_Производитель силовых аппаратов: Y - ДКС; 06_Номер схемного решения_1 часть: 0xx - общесекционное устройство; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Марка: 101
Прочее - 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC: 600 х 300; Семейство: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC: 600 х 300; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC: 600 х 300; Тип: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC: 600 х 300
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.000830517 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 6P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 72; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: Y; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 0; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: 600 х 350, НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC:600 х 350:833982
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Блок свободной конфигурации, 600 х 350; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: 600 х 350; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 03_Номинальный ток_01: 01 = 70-125А; 03_Номинальный ток_02: 02 = 165-200А; 03_Номинальный ток_03: 03 = 260-320 (315)A; 03_Номинальный ток_04: 04 = 330-400A; 03_Номинальный ток_06: 06 = 420-630А; 03_Номинальный ток_08: 08 = 650- 800А; 03_Номинальный ток_10: 10 = 850-1000А; 03_Номинальный ток_12: 12 = 1100-1250А; 03_Номинальный ток_16: 16 = 1300-1600А; 03_Номинальный ток_20: 20 = 1700- 2000А; 03_Номинальный ток_25: 25 = 2100- 2500А; 03_Номинальный ток_32: 32 = 2600-3200А; 03_Номинальный ток_40: 40 = 3500-4000А; 03_Номинальный ток_50: 50 = 4100- 5000А; 03_Номинальный ток_63: 63 = 5100- 6300А; 03_Номинальный ток_70: 70 = 1-63А; 03_Номинальный ток_71: 71 = 130-160; 03_Номинальный ток_72: 72 = 210-250А; 04_Количество полюсов выключателя_1: 1 – полюс; 04_Количество полюсов выключателя_2: 2 – полюса; 04_Количество полюсов выключателя_3: 3 – полюса; 04_Количество полюсов выключателя_4: 4 – полюса; 05_Производитель силовых аппаратов_0: 0 - прочее оборудование; 05_Производитель силовых аппаратов_E: E - Schneider electric; 05_Производитель силовых аппаратов_H: H - Hyundai; 05_Производитель силовых аппаратов_I: I - Siemens; 05_Производитель силовых аппаратов_K: K - КЭАЗ; 05_Производитель силовых аппаратов_L: L - LSIS electric; 05_Производитель силовых аппаратов_Y: Y - ДКС; 05_Производитель силовых аппаратов_А: А - АBB; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_1: 1хх - модульный АВ; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_3: 3хх - воздушный АВ; 06_Номер схемного решения_1 часть_4: 4хх - выключатель - разъединитель; 06_Номер схемного решения_1 часть_5: 5хх - АВ защиты двигателя; 06_Номер схемного решения_1 часть_6: 6xx - модульный АВ с пускорегулятором; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_8: 8xx - АВ защиты двигателя с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; Имя семейства: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC
Type - Размеры - ADSK_Размер_Высота: 350 mm; ADSK_Размер_Ширина: 600 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: 600 х 350
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 03_Номинальный ток: 72 = 210-250А; 04_Количество полюсов выключателя: 3 – полюса; 05_Производитель силовых аппаратов: Y - ДКС; 06_Номер схемного решения_1 часть: 0xx - общесекционное устройство; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 102
Прочее - 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC: 600 х 350; Семейство: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC: 600 х 350; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC: 600 х 350; Тип: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC: 600 х 350
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.000954423 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 7P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 72; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: Y; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 0; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: 800 х 150, НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC:800 х 150:833985
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Блок свободной конфигурации, 800 х 150; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: 800 х 150; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 03_Номинальный ток_01: 01 = 70-125А; 03_Номинальный ток_02: 02 = 165-200А; 03_Номинальный ток_03: 03 = 260-320 (315)A; 03_Номинальный ток_04: 04 = 330-400A; 03_Номинальный ток_06: 06 = 420-630А; 03_Номинальный ток_08: 08 = 650- 800А; 03_Номинальный ток_10: 10 = 850-1000А; 03_Номинальный ток_12: 12 = 1100-1250А; 03_Номинальный ток_16: 16 = 1300-1600А; 03_Номинальный ток_20: 20 = 1700- 2000А; 03_Номинальный ток_25: 25 = 2100- 2500А; 03_Номинальный ток_32: 32 = 2600-3200А; 03_Номинальный ток_40: 40 = 3500-4000А; 03_Номинальный ток_50: 50 = 4100- 5000А; 03_Номинальный ток_63: 63 = 5100- 6300А; 03_Номинальный ток_70: 70 = 1-63А; 03_Номинальный ток_71: 71 = 130-160; 03_Номинальный ток_72: 72 = 210-250А; 04_Количество полюсов выключателя_1: 1 – полюс; 04_Количество полюсов выключателя_2: 2 – полюса; 04_Количество полюсов выключателя_3: 3 – полюса; 04_Количество полюсов выключателя_4: 4 – полюса; 05_Производитель силовых аппаратов_0: 0 - прочее оборудование; 05_Производитель силовых аппаратов_E: E - Schneider electric; 05_Производитель силовых аппаратов_H: H - Hyundai; 05_Производитель силовых аппаратов_I: I - Siemens; 05_Производитель силовых аппаратов_K: K - КЭАЗ; 05_Производитель силовых аппаратов_L: L - LSIS electric; 05_Производитель силовых аппаратов_Y: Y - ДКС; 05_Производитель силовых аппаратов_А: А - АBB; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_1: 1хх - модульный АВ; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_3: 3хх - воздушный АВ; 06_Номер схемного решения_1 часть_4: 4хх - выключатель - разъединитель; 06_Номер схемного решения_1 часть_5: 5хх - АВ защиты двигателя; 06_Номер схемного решения_1 часть_6: 6xx - модульный АВ с пускорегулятором; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_8: 8xx - АВ защиты двигателя с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; Имя семейства: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC
Type - Размеры - ADSK_Размер_Высота: 150 mm; ADSK_Размер_Ширина: 800 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: 800 х 150
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 03_Номинальный ток: 72 = 210-250А; 04_Количество полюсов выключателя: 3 – полюса; 05_Производитель силовых аппаратов: Y - ДКС; 06_Номер схемного решения_1 часть: 0xx - общесекционное устройство; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Марка: 103
Прочее - 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC: 800 х 150; Семейство: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC: 800 х 150; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC: 800 х 150; Тип: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC: 800 х 150
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.0005788 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 3P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 72; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: Y; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 0; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 8
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: 800 х 200, НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC:800 х 200:833988
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Блок свободной конфигурации, 800 х 200; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: 800 х 200; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 03_Номинальный ток_01: 01 = 70-125А; 03_Номинальный ток_02: 02 = 165-200А; 03_Номинальный ток_03: 03 = 260-320 (315)A; 03_Номинальный ток_04: 04 = 330-400A; 03_Номинальный ток_06: 06 = 420-630А; 03_Номинальный ток_08: 08 = 650- 800А; 03_Номинальный ток_10: 10 = 850-1000А; 03_Номинальный ток_12: 12 = 1100-1250А; 03_Номинальный ток_16: 16 = 1300-1600А; 03_Номинальный ток_20: 20 = 1700- 2000А; 03_Номинальный ток_25: 25 = 2100- 2500А; 03_Номинальный ток_32: 32 = 2600-3200А; 03_Номинальный ток_40: 40 = 3500-4000А; 03_Номинальный ток_50: 50 = 4100- 5000А; 03_Номинальный ток_63: 63 = 5100- 6300А; 03_Номинальный ток_70: 70 = 1-63А; 03_Номинальный ток_71: 71 = 130-160; 03_Номинальный ток_72: 72 = 210-250А; 04_Количество полюсов выключателя_1: 1 – полюс; 04_Количество полюсов выключателя_2: 2 – полюса; 04_Количество полюсов выключателя_3: 3 – полюса; 04_Количество полюсов выключателя_4: 4 – полюса; 05_Производитель силовых аппаратов_0: 0 - прочее оборудование; 05_Производитель силовых аппаратов_E: E - Schneider electric; 05_Производитель силовых аппаратов_H: H - Hyundai; 05_Производитель силовых аппаратов_I: I - Siemens; 05_Производитель силовых аппаратов_K: K - КЭАЗ; 05_Производитель силовых аппаратов_L: L - LSIS electric; 05_Производитель силовых аппаратов_Y: Y - ДКС; 05_Производитель силовых аппаратов_А: А - АBB; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_1: 1хх - модульный АВ; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_3: 3хх - воздушный АВ; 06_Номер схемного решения_1 часть_4: 4хх - выключатель - разъединитель; 06_Номер схемного решения_1 часть_5: 5хх - АВ защиты двигателя; 06_Номер схемного решения_1 часть_6: 6xx - модульный АВ с пускорегулятором; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_8: 8xx - АВ защиты двигателя с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; Имя семейства: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC
Type - Размеры - ADSK_Размер_Высота: 200 mm; ADSK_Размер_Ширина: 800 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: 800 х 200
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 03_Номинальный ток: 72 = 210-250А; 04_Количество полюсов выключателя: 3 – полюса; 05_Производитель силовых аппаратов: Y - ДКС; 06_Номер схемного решения_1 часть: 0xx - общесекционное устройство; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 104
Прочее - 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC: 800 х 200; Семейство: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC: 800 х 200; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC: 800 х 200; Тип: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC: 800 х 200
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.000742705 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 4P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 72; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: Y; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 0; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 8
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: 800 х 250, НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC:800 х 250:833991
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Блок свободной конфигурации, 800 х 250; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: 800 х 250; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 03_Номинальный ток_01: 01 = 70-125А; 03_Номинальный ток_02: 02 = 165-200А; 03_Номинальный ток_03: 03 = 260-320 (315)A; 03_Номинальный ток_04: 04 = 330-400A; 03_Номинальный ток_06: 06 = 420-630А; 03_Номинальный ток_08: 08 = 650- 800А; 03_Номинальный ток_10: 10 = 850-1000А; 03_Номинальный ток_12: 12 = 1100-1250А; 03_Номинальный ток_16: 16 = 1300-1600А; 03_Номинальный ток_20: 20 = 1700- 2000А; 03_Номинальный ток_25: 25 = 2100- 2500А; 03_Номинальный ток_32: 32 = 2600-3200А; 03_Номинальный ток_40: 40 = 3500-4000А; 03_Номинальный ток_50: 50 = 4100- 5000А; 03_Номинальный ток_63: 63 = 5100- 6300А; 03_Номинальный ток_70: 70 = 1-63А; 03_Номинальный ток_71: 71 = 130-160; 03_Номинальный ток_72: 72 = 210-250А; 04_Количество полюсов выключателя_1: 1 – полюс; 04_Количество полюсов выключателя_2: 2 – полюса; 04_Количество полюсов выключателя_3: 3 – полюса; 04_Количество полюсов выключателя_4: 4 – полюса; 05_Производитель силовых аппаратов_0: 0 - прочее оборудование; 05_Производитель силовых аппаратов_E: E - Schneider electric; 05_Производитель силовых аппаратов_H: H - Hyundai; 05_Производитель силовых аппаратов_I: I - Siemens; 05_Производитель силовых аппаратов_K: K - КЭАЗ; 05_Производитель силовых аппаратов_L: L - LSIS electric; 05_Производитель силовых аппаратов_Y: Y - ДКС; 05_Производитель силовых аппаратов_А: А - АBB; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_1: 1хх - модульный АВ; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_3: 3хх - воздушный АВ; 06_Номер схемного решения_1 часть_4: 4хх - выключатель - разъединитель; 06_Номер схемного решения_1 часть_5: 5хх - АВ защиты двигателя; 06_Номер схемного решения_1 часть_6: 6xx - модульный АВ с пускорегулятором; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_8: 8xx - АВ защиты двигателя с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; Имя семейства: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC
Type - Размеры - ADSK_Размер_Высота: 250 mm; ADSK_Размер_Ширина: 800 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: 800 х 250
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 03_Номинальный ток: 72 = 210-250А; 04_Количество полюсов выключателя: 3 – полюса; 05_Производитель силовых аппаратов: Y - ДКС; 06_Номер схемного решения_1 часть: 0xx - общесекционное устройство; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Марка: 105
Прочее - 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC: 800 х 250; Семейство: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC: 800 х 250; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC: 800 х 250; Тип: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC: 800 х 250
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.000906611 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 5P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 72; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: Y; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 0; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 8
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: 800 х 300, НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC:800 х 300:833994
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Блок свободной конфигурации, 800 х 300; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: 800 х 300; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 03_Номинальный ток_01: 01 = 70-125А; 03_Номинальный ток_02: 02 = 165-200А; 03_Номинальный ток_03: 03 = 260-320 (315)A; 03_Номинальный ток_04: 04 = 330-400A; 03_Номинальный ток_06: 06 = 420-630А; 03_Номинальный ток_08: 08 = 650- 800А; 03_Номинальный ток_10: 10 = 850-1000А; 03_Номинальный ток_12: 12 = 1100-1250А; 03_Номинальный ток_16: 16 = 1300-1600А; 03_Номинальный ток_20: 20 = 1700- 2000А; 03_Номинальный ток_25: 25 = 2100- 2500А; 03_Номинальный ток_32: 32 = 2600-3200А; 03_Номинальный ток_40: 40 = 3500-4000А; 03_Номинальный ток_50: 50 = 4100- 5000А; 03_Номинальный ток_63: 63 = 5100- 6300А; 03_Номинальный ток_70: 70 = 1-63А; 03_Номинальный ток_71: 71 = 130-160; 03_Номинальный ток_72: 72 = 210-250А; 04_Количество полюсов выключателя_1: 1 – полюс; 04_Количество полюсов выключателя_2: 2 – полюса; 04_Количество полюсов выключателя_3: 3 – полюса; 04_Количество полюсов выключателя_4: 4 – полюса; 05_Производитель силовых аппаратов_0: 0 - прочее оборудование; 05_Производитель силовых аппаратов_E: E - Schneider electric; 05_Производитель силовых аппаратов_H: H - Hyundai; 05_Производитель силовых аппаратов_I: I - Siemens; 05_Производитель силовых аппаратов_K: K - КЭАЗ; 05_Производитель силовых аппаратов_L: L - LSIS electric; 05_Производитель силовых аппаратов_Y: Y - ДКС; 05_Производитель силовых аппаратов_А: А - АBB; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_1: 1хх - модульный АВ; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_3: 3хх - воздушный АВ; 06_Номер схемного решения_1 часть_4: 4хх - выключатель - разъединитель; 06_Номер схемного решения_1 часть_5: 5хх - АВ защиты двигателя; 06_Номер схемного решения_1 часть_6: 6xx - модульный АВ с пускорегулятором; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_8: 8xx - АВ защиты двигателя с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; Имя семейства: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC
Type - Размеры - ADSK_Размер_Высота: 300 mm; ADSK_Размер_Ширина: 800 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: 800 х 300
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 03_Номинальный ток: 72 = 210-250А; 04_Количество полюсов выключателя: 3 – полюса; 05_Производитель силовых аппаратов: Y - ДКС; 06_Номер схемного решения_1 часть: 0xx - общесекционное устройство; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 106
Прочее - 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC: 800 х 300; Семейство: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC: 800 х 300; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC: 800 х 300; Тип: НВО_RAMPower_ФункциональныйБлок_СвободнойКонфигурации_DKC: 800 х 300
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.00107052 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 6P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 72; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: Y; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 0; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 8
