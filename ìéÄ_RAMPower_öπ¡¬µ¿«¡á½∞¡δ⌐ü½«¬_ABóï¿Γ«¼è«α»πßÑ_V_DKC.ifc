Properties of the parts of a building model (IFC2X3), part 1 of 6

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2022-10-07T01:46:19
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181217_1515(x64) - Exporter 19.2.0.65 - Альтернативный интерфейс 19.2.0.65
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Oct 07 01:46:19 2022 * Host: SERGEY_MIKHALEV * Database: C:\Users\mkhlv\AppData\Local\Temp\{AD89B93D-ABF9-4B52-A969-5EF14C208EC0}\ifc * Database version: 5507 * Database creation date: Fri Oct 07 01:46:14 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Oct 07 01:46:14 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Oct 07 01:46:14 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2022
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2022
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее(Type) - Категория: Уровни; Имя семейства: Уровень
Идентификация(Type) - Имя типа: Отметка уровня с именем
Зависимости(Type) - Базовая отметка: Базовая точка проекта
Графика(Type) - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Зависимости - Фасад: 0 mm
Идентификация - Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Прочее - Категория: Уровни; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Размеры - Расчетная высота: 0 mm

# IfcBuildingElementProxy: ABB, T4 (F, F-MO), 600х250, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC:ABB, T4 (F, F-MO), 600х250:890459
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок AB в литом корпусе (V), ABB, T4 (F, F-MO), 600х250; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: ABB, T4 (F, F-MO), 600х250; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 03; 05_Производитель силовых аппаратов: A; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC
Type - Размеры - Максимальное количество АВ в блоке_мм: 0 mm; ADSK_Размер_Высота: 250 mm; ADSK_Размер_Ширина: 600 mm
Type - Строительство - Максимальное количество АВ в блоке: 3
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: ABB, T4 (F, F-MO), 600х250
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 2хх - АВ в литом корпусе; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Марка: 262
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (F, F-MO), 600х250; Семейство: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (F, F-MO), 600х250; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (F, F-MO), 600х250; Тип: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (F, F-MO), 600х250
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.00868748 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм; Количество АВ в блоке: 1
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 5P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 03; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: A; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 2; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: ABB, T4 (F, F-MO), 800х250, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC:ABB, T4 (F, F-MO), 800х250:890499
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок AB в литом корпусе (V), ABB, T4 (F, F-MO), 800х250; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: ABB, T4 (F, F-MO), 800х250; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 03; 05_Производитель силовых аппаратов: A; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC
Type - Размеры - Максимальное количество АВ в блоке_мм: 0 mm; ADSK_Размер_Высота: 250 mm; ADSK_Размер_Ширина: 800 mm
Type - Строительство - Максимальное количество АВ в блоке: 5
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: ABB, T4 (F, F-MO), 800х250
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 2хх - АВ в литом корпусе; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 267
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (F, F-MO), 800х250; Семейство: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (F, F-MO), 800х250; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (F, F-MO), 800х250; Тип: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (F, F-MO), 800х250
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.0071294 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм; Количество АВ в блоке: 1
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 5P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 03; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: A; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 2; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 8
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: ABB, T4 (P), 600х250, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC:ABB, T4 (P), 600х250:890487
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок AB в литом корпусе (V), ABB, T4 (P), 600х250; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: ABB, T4 (P), 600х250; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 03; 05_Производитель силовых аппаратов: A; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC
Type - Размеры - Максимальное количество АВ в блоке_мм: 0 mm; ADSK_Размер_Высота: 250 mm; ADSK_Размер_Ширина: 600 mm
Type - Строительство - Максимальное количество АВ в блоке: 3
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: ABB, T4 (P), 600х250
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 2хх - АВ в литом корпусе; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Марка: 263
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (P), 600х250; Семейство: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (P), 600х250; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (P), 600х250; Тип: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (P), 600х250
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.00868748 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм; Количество АВ в блоке: 1
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 5P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 03; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: A; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 2; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: ABB, T4 (P), 800х250, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC:ABB, T4 (P), 800х250:890502
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок AB в литом корпусе (V), ABB, T4 (P), 800х250; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: ABB, T4 (P), 800х250; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 03; 05_Производитель силовых аппаратов: A; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC
Type - Размеры - Максимальное количество АВ в блоке_мм: 0 mm; ADSK_Размер_Высота: 250 mm; ADSK_Размер_Ширина: 800 mm
Type - Строительство - Максимальное количество АВ в блоке: 5
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: ABB, T4 (P), 800х250
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 2хх - АВ в литом корпусе; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 268
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (P), 800х250; Семейство: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (P), 800х250; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (P), 800х250; Тип: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (P), 800х250
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.0071294 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм; Количество АВ в блоке: 1
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 5P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 03; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: A; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 2; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 8
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: ABB, T4 (P-MO), 600х250, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC:ABB, T4 (P-MO), 600х250:890490
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок AB в литом корпусе (V), ABB, T4 (P-MO), 600х250; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: ABB, T4 (P-MO), 600х250; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 03; 05_Производитель силовых аппаратов: A; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC
Type - Размеры - Максимальное количество АВ в блоке_мм: 0 mm; ADSK_Размер_Высота: 250 mm; ADSK_Размер_Ширина: 600 mm
Type - Строительство - Максимальное количество АВ в блоке: 3
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: ABB, T4 (P-MO), 600х250
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 2хх - АВ в литом корпусе; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Марка: 264
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (P-MO), 600х250; Семейство: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (P-MO), 600х250; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (P-MO), 600х250; Тип: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (P-MO), 600х250
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.00868748 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм; Количество АВ в блоке: 1
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 5P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 03; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: A; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 2; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: ABB, T4 (P-MO), 800х250, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC:ABB, T4 (P-MO), 800х250:890505
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок AB в литом корпусе (V), ABB, T4 (P-MO), 800х250; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: ABB, T4 (P-MO), 800х250; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 03; 05_Производитель силовых аппаратов: A; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC
Type - Размеры - Максимальное количество АВ в блоке_мм: 0 mm; ADSK_Размер_Высота: 250 mm; ADSK_Размер_Ширина: 800 mm
Type - Строительство - Максимальное количество АВ в блоке: 5
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: ABB, T4 (P-MO), 800х250
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 2хх - АВ в литом корпусе; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Марка: 269
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (P-MO), 800х250; Семейство: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (P-MO), 800х250; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (P-MO), 800х250; Тип: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (P-MO), 800х250
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.0071294 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм; Количество АВ в блоке: 1
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 5P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 03; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: A; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 2; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 8
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: ABB, T4 (W), 600х250, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC:ABB, T4 (W), 600х250:890493
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок AB в литом корпусе (V), ABB, T4 (W), 600х250; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: ABB, T4 (W), 600х250; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 03; 05_Производитель силовых аппаратов: A; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC
Type - Размеры - Максимальное количество АВ в блоке_мм: 0 mm; ADSK_Размер_Высота: 250 mm; ADSK_Размер_Ширина: 600 mm
Type - Строительство - Максимальное количество АВ в блоке: 2
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: ABB, T4 (W), 600х250
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 2хх - АВ в литом корпусе; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Марка: 265
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (W), 600х250; Семейство: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (W), 600х250; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (W), 600х250; Тип: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (W), 600х250
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.0141011 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм; Количество АВ в блоке: 1
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 5P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 03; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: A; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 2; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: ABB, T4 (W), 800х250, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC:ABB, T4 (W), 800х250:890508
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок AB в литом корпусе (V), ABB, T4 (W), 800х250; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: ABB, T4 (W), 800х250; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 03; 05_Производитель силовых аппаратов: A; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC
Type - Размеры - Максимальное количество АВ в блоке_мм: 0 mm; ADSK_Размер_Высота: 250 mm; ADSK_Размер_Ширина: 800 mm
Type - Строительство - Максимальное количество АВ в блоке: 3
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: ABB, T4 (W), 800х250
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 2хх - АВ в литом корпусе; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 270
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (W), 800х250; Семейство: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (W), 800х250; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (W), 800х250; Тип: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (W), 800х250
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.0131755 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм; Количество АВ в блоке: 1
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 5P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 03; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: A; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 2; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 8
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: ABB, T4 (W-MO), 600х250, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC:ABB, T4 (W-MO), 600х250:890496
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок AB в литом корпусе (V), ABB, T4 (W-MO), 600х250; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: ABB, T4 (W-MO), 600х250; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 03; 05_Производитель силовых аппаратов: A; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC
Type - Размеры - Максимальное количество АВ в блоке_мм: 0 mm; ADSK_Размер_Высота: 250 mm; ADSK_Размер_Ширина: 600 mm
Type - Строительство - Максимальное количество АВ в блоке: 2
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: ABB, T4 (W-MO), 600х250
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 2хх - АВ в литом корпусе; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 266
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (W-MO), 600х250; Семейство: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (W-MO), 600х250; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (W-MO), 600х250; Тип: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (W-MO), 600х250
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.0141011 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм; Количество АВ в блоке: 1
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 5P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 03; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: A; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 2; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: ABB, T4 (W-MO), 800х250, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC:ABB, T4 (W-MO), 800х250:890511
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок AB в литом корпусе (V), ABB, T4 (W-MO), 800х250; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: ABB, T4 (W-MO), 800х250; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 03; 05_Производитель силовых аппаратов: A; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC
Type - Размеры - Максимальное количество АВ в блоке_мм: 0 mm; ADSK_Размер_Высота: 250 mm; ADSK_Размер_Ширина: 800 mm
Type - Строительство - Максимальное количество АВ в блоке: 3
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: ABB, T4 (W-MO), 800х250
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 2хх - АВ в литом корпусе; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 271
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (W-MO), 800х250; Семейство: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (W-MO), 800х250; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (W-MO), 800х250; Тип: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T4 (W-MO), 800х250
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.0131755 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм; Количество АВ в блоке: 1
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 5P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 03; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: A; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 2; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 8
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: ABB, T5 (F, F-MO), 600х250, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC:ABB, T5 (F, F-MO), 600х250:890514
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок AB в литом корпусе (V), ABB, T5 (F, F-MO), 600х250; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: ABB, T5 (F, F-MO), 600х250; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 06; 05_Производитель силовых аппаратов: A; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC
Type - Размеры - Максимальное количество АВ в блоке_мм: 0 mm; ADSK_Размер_Высота: 250 mm; ADSK_Размер_Ширина: 600 mm
Type - Строительство - Максимальное количество АВ в блоке: 3
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: ABB, T5 (F, F-MO), 600х250
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 2хх - АВ в литом корпусе; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 272
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T5 (F, F-MO), 600х250; Семейство: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T5 (F, F-MO), 600х250; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T5 (F, F-MO), 600х250; Тип: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T5 (F, F-MO), 600х250
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.00868748 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм; Количество АВ в блоке: 1
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 5P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 06; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: A; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 2; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: ABB, T5 (P), 600х350, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC:ABB, T5 (P), 600х350:890517
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок AB в литом корпусе (V), ABB, T5 (P), 600х350; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: ABB, T5 (P), 600х350; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 06; 05_Производитель силовых аппаратов: A; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC
Type - Размеры - Максимальное количество АВ в блоке_мм: 0 mm; ADSK_Размер_Высота: 350 mm; ADSK_Размер_Ширина: 600 mm
Type - Строительство - Максимальное количество АВ в блоке: 2
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: ABB, T5 (P), 600х350
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 2хх - АВ в литом корпусе; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Марка: 273
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T5 (P), 600х350; Семейство: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T5 (P), 600х350; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T5 (P), 600х350; Тип: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ABB, T5 (P), 600х350
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.0143489 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм; Количество АВ в блоке: 1
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 7P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 06; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: A; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 2; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: ABB, T5 (P-MO), 600х350, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC:ABB, T5 (P-MO), 600х350:890520
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок AB в литом корпусе (V), ABB, T5 (P-MO), 600х350; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
