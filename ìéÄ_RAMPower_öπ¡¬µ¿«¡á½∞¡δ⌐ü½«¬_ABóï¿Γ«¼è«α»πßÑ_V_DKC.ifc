Properties of the parts of a building model (IFC2X3), part 5 of 6

# IfcBuildingElementProxy: Schneider electric, NSX630 (F, F-MO, P), 800х350, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC:Schneider electric, NSX630 (F, F-MO, P), 800х350:891661
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: Schneider electric, NSX630 (F, F-MO, P), 800х350; Семейство: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: Schneider electric, NSX630 (F, F-MO, P), 800х350; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: Schneider electric, NSX630 (F, F-MO, P), 800х350; Тип: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: Schneider electric, NSX630 (F, F-MO, P), 800х350
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.00972449 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм; Количество АВ в блоке: 1
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 7P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 06; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: E; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 2; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 8
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: Schneider electric, NSX630 (P-MO), 800х350, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC:Schneider electric, NSX630 (P-MO), 800х350:891663
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок AB в литом корпусе (V), Schneider electric, NSX630 (P-MO), 800х350; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: Schneider electric, NSX630 (P-MO), 800х350; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 06; 05_Производитель силовых аппаратов: E; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC
Type - Размеры - Максимальное количество АВ в блоке_мм: 0 mm; ADSK_Размер_Высота: 350 mm; ADSK_Размер_Ширина: 800 mm
Type - Строительство - Максимальное количество АВ в блоке: 4
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: Schneider electric, NSX630 (P-MO), 800х350
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 2хх - АВ в литом корпусе; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 310
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: Schneider electric, NSX630 (P-MO), 800х350; Семейство: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: Schneider electric, NSX630 (P-MO), 800х350; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: Schneider electric, NSX630 (P-MO), 800х350; Тип: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: Schneider electric, NSX630 (P-MO), 800х350
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.00972449 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм; Количество АВ в блоке: 1
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 7P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 06; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: E; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 2; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 8
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: Schneider electric, NSX630 (W), 600х350, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC:Schneider electric, NSX630 (W), 600х350:891605
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок AB в литом корпусе (V), Schneider electric, NSX630 (W), 600х350; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: Schneider electric, NSX630 (W), 600х350; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 06; 05_Производитель силовых аппаратов: E; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC
Type - Размеры - Максимальное количество АВ в блоке_мм: 0 mm; ADSK_Размер_Высота: 350 mm; ADSK_Размер_Ширина: 600 mm
Type - Строительство - Максимальное количество АВ в блоке: 2
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: Schneider electric, NSX630 (W), 600х350
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 2хх - АВ в литом корпусе; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 306
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: Schneider electric, NSX630 (W), 600х350; Семейство: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: Schneider electric, NSX630 (W), 600х350; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: Schneider electric, NSX630 (W), 600х350; Тип: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: Schneider electric, NSX630 (W), 600х350
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.0143489 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм; Количество АВ в блоке: 1
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 7P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 06; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: E; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 2; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: Schneider electric, NSX630 (W), 800х350, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC:Schneider electric, NSX630 (W), 800х350:891662
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок AB в литом корпусе (V), Schneider electric, NSX630 (W), 800х350; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: Schneider electric, NSX630 (W), 800х350; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 06; 05_Производитель силовых аппаратов: E; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC
Type - Размеры - Максимальное количество АВ в блоке_мм: 0 mm; ADSK_Размер_Высота: 350 mm; ADSK_Размер_Ширина: 800 mm
Type - Строительство - Максимальное количество АВ в блоке: 2
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: Schneider electric, NSX630 (W), 800х350
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 2хх - АВ в литом корпусе; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Марка: 309
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: Schneider electric, NSX630 (W), 800х350; Семейство: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: Schneider electric, NSX630 (W), 800х350; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: Schneider electric, NSX630 (W), 800х350; Тип: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: Schneider electric, NSX630 (W), 800х350
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.0210609 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм; Количество АВ в блоке: 1
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 7P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 06; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: E; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 2; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 8
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: Schneider electric, NSX630 (W-MO), 800х350, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC:Schneider electric, NSX630 (W-MO), 800х350:891664
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок AB в литом корпусе (V), Schneider electric, NSX630 (W-MO), 800х350; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: Schneider electric, NSX630 (W-MO), 800х350; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 06; 05_Производитель силовых аппаратов: E; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC
Type - Размеры - Максимальное количество АВ в блоке_мм: 0 mm; ADSK_Размер_Высота: 350 mm; ADSK_Размер_Ширина: 800 mm
Type - Строительство - Максимальное количество АВ в блоке: 2
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: Schneider electric, NSX630 (W-MO), 800х350
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 2хх - АВ в литом корпусе; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 311
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: Schneider electric, NSX630 (W-MO), 800х350; Семейство: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: Schneider electric, NSX630 (W-MO), 800х350; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: Schneider electric, NSX630 (W-MO), 800х350; Тип: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: Schneider electric, NSX630 (W-MO), 800х350
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.0210609 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм; Количество АВ в блоке: 1
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 7P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 06; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: E; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 2; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 8
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: Schneider electric, NSX630 (W-MO, P-MO), 600х350, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC:Schneider electric, NSX630 (W-MO, P-MO), 600х350:891660
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок AB в литом корпусе (V), Schneider electric, NSX630 (W-MO, P-MO), 600х350; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: Schneider electric, NSX630 (W-MO, P-MO), 600х350; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 06; 05_Производитель силовых аппаратов: E; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC
Type - Размеры - Максимальное количество АВ в блоке_мм: 0 mm; ADSK_Размер_Высота: 350 mm; ADSK_Размер_Ширина: 600 mm
Type - Строительство - Максимальное количество АВ в блоке: 2
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: Schneider electric, NSX630 (W-MO, P-MO), 600х350
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 2хх - АВ в литом корпусе; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 307
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: Schneider electric, NSX630 (W-MO, P-MO), 600х350; Семейство: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: Schneider electric, NSX630 (W-MO, P-MO), 600х350; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: Schneider electric, NSX630 (W-MO, P-MO), 600х350; Тип: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: Schneider electric, NSX630 (W-MO, P-MO), 600х350
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.0143489 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм; Количество АВ в блоке: 1
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 7P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 06; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: E; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 2; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: ДКС, MD250 (F, F-MO, P, P-MO), 600х250, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC:ДКС, MD250 (F, F-MO, P, P-MO), 600х250:891904
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок AB в литом корпусе (V), ДКС, MD250 (F, F-MO, P, P-MO), 600х250; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: ДКС, MD250 (F, F-MO, P, P-MO), 600х250; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 72; 05_Производитель силовых аппаратов: Y; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC
Type - Размеры - Максимальное количество АВ в блоке_мм: 0 mm; ADSK_Размер_Высота: 250 mm; ADSK_Размер_Ширина: 600 mm
Type - Строительство - Максимальное количество АВ в блоке: 4
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: ДКС, MD250 (F, F-MO, P, P-MO), 600х250
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 2хх - АВ в литом корпусе; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Марка: 315
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ДКС, MD250 (F, F-MO, P, P-MO), 600х250; Семейство: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ДКС, MD250 (F, F-MO, P, P-MO), 600х250; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ДКС, MD250 (F, F-MO, P, P-MO), 600х250; Тип: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ДКС, MD250 (F, F-MO, P, P-MO), 600х250
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.00598068 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм; Количество АВ в блоке: 1
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 5P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 72; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: Y; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 2; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: ДКС, MD250 (W, W-MO), 600х250, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC:ДКС, MD250 (W, W-MO), 600х250:891905
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок AB в литом корпусе (V), ДКС, MD250 (W, W-MO), 600х250; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: ДКС, MD250 (W, W-MO), 600х250; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 72; 05_Производитель силовых аппаратов: Y; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC
Type - Размеры - Максимальное количество АВ в блоке_мм: 0 mm; ADSK_Размер_Высота: 250 mm; ADSK_Размер_Ширина: 600 mm
Type - Строительство - Максимальное количество АВ в блоке: 2
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: ДКС, MD250 (W, W-MO), 600х250
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 2хх - АВ в литом корпусе; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Марка: 316
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ДКС, MD250 (W, W-MO), 600х250; Семейство: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ДКС, MD250 (W, W-MO), 600х250; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ДКС, MD250 (W, W-MO), 600х250; Тип: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ДКС, MD250 (W, W-MO), 600х250
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.0141011 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм; Количество АВ в блоке: 1
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 5P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 72; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: Y; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 2; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: ДКС, MD630 (F, F-MO, P), 600х350, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC:ДКС, MD630 (F, F-MO, P), 600х350:891906
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок AB в литом корпусе (V), ДКС, MD630 (F, F-MO, P), 600х350; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: ДКС, MD630 (F, F-MO, P), 600х350; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 06; 05_Производитель силовых аппаратов: Y; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC
Type - Размеры - Максимальное количество АВ в блоке_мм: 0 mm; ADSK_Размер_Высота: 350 mm; ADSK_Размер_Ширина: 600 mm
Type - Строительство - Максимальное количество АВ в блоке: 3
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: ДКС, MD630 (F, F-MO, P), 600х350
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 2хх - АВ в литом корпусе; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 317
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ДКС, MD630 (F, F-MO, P), 600х350; Семейство: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ДКС, MD630 (F, F-MO, P), 600х350; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ДКС, MD630 (F, F-MO, P), 600х350; Тип: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ДКС, MD630 (F, F-MO, P), 600х350
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.00893529 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм; Количество АВ в блоке: 1
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 7P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 06; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: Y; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 2; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: ДКС, MD630 (P-MO), 600х350, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC:ДКС, MD630 (P-MO), 600х350:891908
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок AB в литом корпусе (V), ДКС, MD630 (P-MO), 600х350; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: ДКС, MD630 (P-MO), 600х350; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 06; 05_Производитель силовых аппаратов: Y; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC
Type - Размеры - Максимальное количество АВ в блоке_мм: 0 mm; ADSK_Размер_Высота: 350 mm; ADSK_Размер_Ширина: 600 mm
Type - Строительство - Максимальное количество АВ в блоке: 2
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: ДКС, MD630 (P-MO), 600х350
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 2хх - АВ в литом корпусе; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Марка: 319
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ДКС, MD630 (P-MO), 600х350; Семейство: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ДКС, MD630 (P-MO), 600х350; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ДКС, MD630 (P-MO), 600х350; Тип: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ДКС, MD630 (P-MO), 600х350
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.0143489 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм; Количество АВ в блоке: 1
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 7P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 06; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: Y; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 2; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: ДКС, MD630 (W), 600х350, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC:ДКС, MD630 (W), 600х350:891907
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок AB в литом корпусе (V), ДКС, MD630 (W), 600х350; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: ДКС, MD630 (W), 600х350; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 06; 05_Производитель силовых аппаратов: Y; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC
Type - Размеры - Максимальное количество АВ в блоке_мм: 0 mm; ADSK_Размер_Высота: 350 mm; ADSK_Размер_Ширина: 600 mm
Type - Строительство - Максимальное количество АВ в блоке: 2
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: ДКС, MD630 (W), 600х350
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 2хх - АВ в литом корпусе; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Марка: 318
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ДКС, MD630 (W), 600х350; Семейство: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ДКС, MD630 (W), 600х350; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ДКС, MD630 (W), 600х350; Тип: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ДКС, MD630 (W), 600х350
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.0143489 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм; Количество АВ в блоке: 1
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 7P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 06; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: Y; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 2; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: ДКС, MD630 (W-MO), 600х350, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC:ДКС, MD630 (W-MO), 600х350:891909
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок AB в литом корпусе (V), ДКС, MD630 (W-MO), 600х350; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: ДКС, MD630 (W-MO), 600х350; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 06; 05_Производитель силовых аппаратов: Y; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC
Type - Размеры - Максимальное количество АВ в блоке_мм: 0 mm; ADSK_Размер_Высота: 350 mm; ADSK_Размер_Ширина: 600 mm
Type - Строительство - Максимальное количество АВ в блоке: 2
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: ДКС, MD630 (W-MO), 600х350
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 2хх - АВ в литом корпусе; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Марка: 320
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ДКС, MD630 (W-MO), 600х350; Семейство: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ДКС, MD630 (W-MO), 600х350; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ДКС, MD630 (W-MO), 600х350; Тип: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ДКС, MD630 (W-MO), 600х350
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.0143489 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм; Количество АВ в блоке: 1
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 7P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 06; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: Y; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 2; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: ДКС, MDE100 (F), 600х150, НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC:ДКС, MDE100 (F), 600х150:891901
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Светлый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок AB в литом корпусе (V), ДКС, MDE100 (F), 600х150; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: ДКС, MDE100 (F), 600х150; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_2: 2хх - АВ в литом корпусе; 06_Номер схемного решения_1 часть_7: 7xx - АВ в литом корпусе с пускорегулятором; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 70; 05_Производитель силовых аппаратов: Y; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC
Type - Размеры - Максимальное количество АВ в блоке_мм: 0 mm; ADSK_Размер_Высота: 150 mm; ADSK_Размер_Ширина: 600 mm
Type - Строительство - Максимальное количество АВ в блоке: 5
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: ДКС, MDE100 (F), 600х150
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 2хх - АВ в литом корпусе; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 313
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ДКС, MDE100 (F), 600х150; Семейство: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ДКС, MDE100 (F), 600х150; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ДКС, MDE100 (F), 600х150; Тип: НВО_RAMPower_ФункциональныйБлок_ABвЛитомКорпусе_V_DKC: ДКС, MDE100 (F), 600х150
Размеры - ADSK_Размер_Глубина: 400 mm; Объем: 0.00410878 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 400 мм; Количество АВ в блоке: 1
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 3P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 70; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: Y; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 2; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
