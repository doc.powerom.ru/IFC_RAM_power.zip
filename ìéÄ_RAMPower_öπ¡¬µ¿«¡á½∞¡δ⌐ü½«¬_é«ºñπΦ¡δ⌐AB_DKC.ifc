Properties of the parts of a building model (IFC2X3), part 2 of 5

# IfcBuildingElementProxy: Hyundai, HGN16B, 600 х 600, НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC:Hyundai, HGN16B, 600 х 600:845005
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_3: 3хх - воздушный АВ; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 16; 05_Производитель силовых аппаратов: H; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC
Type - Размеры - ADSK_Размер_Высота: 600 mm; ADSK_Размер_Ширина: 600 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: Hyundai, HGN16B, 600 х 600
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 3хх - воздушный АВ; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Марка: 155
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGN16B, 600 х 600; Семейство: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGN16B, 600 х 600; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGN16B, 600 х 600; Тип: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGN16B, 600 х 600
Размеры - ADSK_Размер_Глубина: 600 mm; Объем: 0.0374034 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 600 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 12P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 16; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: H; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 3; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: Hyundai, HGN20A, 600 х 600, НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC:Hyundai, HGN20A, 600 х 600:844995
In: Этаж 01
Type - Material: DKC_Металл_Светлый, DKC_Металл_Серый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок воздушный AB, Hyundai, HGN20A, 600 х 600; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: Hyundai, HGN20A, 600 х 600; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_3: 3хх - воздушный АВ; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 20; 05_Производитель силовых аппаратов: H; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC
Type - Размеры - ADSK_Размер_Высота: 600 mm; ADSK_Размер_Ширина: 600 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: Hyundai, HGN20A, 600 х 600
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 3хх - воздушный АВ; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 145
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGN20A, 600 х 600; Семейство: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGN20A, 600 х 600; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGN20A, 600 х 600; Тип: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGN20A, 600 х 600
Размеры - ADSK_Размер_Глубина: 600 mm; Объем: 0.0374034 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 600 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 12P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 20; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: H; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 3; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: Hyundai, HGN20B, 600 х 600, НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC:Hyundai, HGN20B, 600 х 600:845078
In: Этаж 01
Type - Material: DKC_Металл_Светлый, DKC_Металл_Серый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок воздушный AB, Hyundai, HGN20B, 600 х 600; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: Hyundai, HGN20B, 600 х 600; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_3: 3хх - воздушный АВ; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 20; 05_Производитель силовых аппаратов: H; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC
Type - Размеры - ADSK_Размер_Высота: 600 mm; ADSK_Размер_Ширина: 600 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: Hyundai, HGN20B, 600 х 600
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 3хх - воздушный АВ; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 156
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGN20B, 600 х 600; Семейство: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGN20B, 600 х 600; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGN20B, 600 х 600; Тип: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGN20B, 600 х 600
Размеры - ADSK_Размер_Глубина: 600 mm; Объем: 0.0374034 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 600 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 12P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 20; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: H; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 3; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: Hyundai, HGN25B, 600 х 600, НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC:Hyundai, HGN25B, 600 х 600:845079
In: Этаж 01
Type - Material: DKC_Металл_Светлый, DKC_Металл_Серый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок воздушный AB, Hyundai, HGN25B, 600 х 600; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: Hyundai, HGN25B, 600 х 600; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_3: 3хх - воздушный АВ; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 25; 05_Производитель силовых аппаратов: H; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC
Type - Размеры - ADSK_Размер_Высота: 600 mm; ADSK_Размер_Ширина: 600 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: Hyundai, HGN25B, 600 х 600
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 3хх - воздушный АВ; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Марка: 157
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGN25B, 600 х 600; Семейство: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGN25B, 600 х 600; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGN25B, 600 х 600; Тип: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGN25B, 600 х 600
Размеры - ADSK_Размер_Глубина: 600 mm; Объем: 0.0374034 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 600 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 12P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 25; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: H; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 3; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: Hyundai, HGN32B, 600 х 600, НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC:Hyundai, HGN32B, 600 х 600:845083
In: Этаж 01
Type - Material: DKC_Металл_Светлый, DKC_Металл_Серый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок воздушный AB, Hyundai, HGN32B, 600 х 600; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: Hyundai, HGN32B, 600 х 600; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_3: 3хх - воздушный АВ; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 32; 05_Производитель силовых аппаратов: H; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC
Type - Размеры - ADSK_Размер_Высота: 600 mm; ADSK_Размер_Ширина: 600 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: Hyundai, HGN32B, 600 х 600
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 3хх - воздушный АВ; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 161
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGN32B, 600 х 600; Семейство: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGN32B, 600 х 600; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGN32B, 600 х 600; Тип: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGN32B, 600 х 600
Размеры - ADSK_Размер_Глубина: 600 mm; Объем: 0.0374034 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 600 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 12P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 32; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: H; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 3; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: Hyundai, HGN32C, 1000 х 600, НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC:Hyundai, HGN32C, 1000 х 600:845085
In: Этаж 01
Type - Material: DKC_Металл_Светлый, DKC_Металл_Серый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок воздушный AB, Hyundai, HGN32C, 1000 х 600; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: Hyundai, HGN32C, 1000 х 600; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_3: 3хх - воздушный АВ; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 32; 05_Производитель силовых аппаратов: H; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC
Type - Размеры - ADSK_Размер_Высота: 600 mm; ADSK_Размер_Ширина: 1000 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: Hyundai, HGN32C, 1000 х 600
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 3хх - воздушный АВ; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Марка: 163
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGN32C, 1000 х 600; Семейство: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGN32C, 1000 х 600; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGN32C, 1000 х 600; Тип: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGN32C, 1000 х 600
Размеры - ADSK_Размер_Глубина: 600 mm; Объем: 0.0861812 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 600 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 12P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 32; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: H; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 3; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: Hyundai, HGN40B, 800 х 600, НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC:Hyundai, HGN40B, 800 х 600:845084
In: Этаж 01
Type - Material: DKC_Металл_Светлый, DKC_Металл_Серый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок воздушный AB, Hyundai, HGN40B, 800 х 600; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: Hyundai, HGN40B, 800 х 600; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_3: 3хх - воздушный АВ; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 40; 05_Производитель силовых аппаратов: H; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC
Type - Размеры - ADSK_Размер_Высота: 600 mm; ADSK_Размер_Ширина: 800 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: Hyundai, HGN40B, 800 х 600
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 3хх - воздушный АВ; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 162
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGN40B, 800 х 600; Семейство: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGN40B, 800 х 600; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGN40B, 800 х 600; Тип: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGN40B, 800 х 600
Размеры - ADSK_Размер_Глубина: 600 mm; Объем: 0.0617923 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 600 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 12P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 40; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: H; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 3; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 8
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: Hyundai, HGN40C, 1000 х 600, НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC:Hyundai, HGN40C, 1000 х 600:845086
In: Этаж 01
Type - Material: DKC_Металл_Светлый, DKC_Металл_Серый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок воздушный AB, Hyundai, HGN40C, 1000 х 600; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: Hyundai, HGN40C, 1000 х 600; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_3: 3хх - воздушный АВ; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 40; 05_Производитель силовых аппаратов: H; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC
Type - Размеры - ADSK_Размер_Высота: 600 mm; ADSK_Размер_Ширина: 1000 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: Hyundai, HGN40C, 1000 х 600
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 3хх - воздушный АВ; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Марка: 164
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGN40C, 1000 х 600; Семейство: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGN40C, 1000 х 600; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGN40C, 1000 х 600; Тип: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGN40C, 1000 х 600
Размеры - ADSK_Размер_Глубина: 600 mm; Объем: 0.0861812 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 600 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 12P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 40; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: H; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 3; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: Hyundai, HGN40D, 1000 х 600, НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC:Hyundai, HGN40D, 1000 х 600:845087
In: Этаж 01
Type - Material: DKC_Металл_Светлый, DKC_Металл_Серый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок воздушный AB, Hyundai, HGN40D, 1000 х 600; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: Hyundai, HGN40D, 1000 х 600; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_3: 3хх - воздушный АВ; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 40; 05_Производитель силовых аппаратов: H; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC
Type - Размеры - ADSK_Размер_Высота: 600 mm; ADSK_Размер_Ширина: 1000 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: Hyundai, HGN40D, 1000 х 600
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 3хх - воздушный АВ; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Марка: 165
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGN40D, 1000 х 600; Семейство: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGN40D, 1000 х 600; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGN40D, 1000 х 600; Тип: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGN40D, 1000 х 600
Размеры - ADSK_Размер_Глубина: 600 mm; Объем: 0.0861812 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 600 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 12P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 40; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: H; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 3; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: Hyundai, HGS06А, 600 х 600, НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC:Hyundai, HGS06А, 600 х 600:844996
In: Этаж 01
Type - Material: DKC_Металл_Светлый, DKC_Металл_Серый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок воздушный AB, Hyundai, HGS06А, 600 х 600; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: Hyundai, HGS06А, 600 х 600; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_3: 3хх - воздушный АВ; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 6; 05_Производитель силовых аппаратов: H; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC
Type - Размеры - ADSK_Размер_Высота: 600 mm; ADSK_Размер_Ширина: 600 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: Hyundai, HGS06А, 600 х 600
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 3хх - воздушный АВ; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 146
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGS06А, 600 х 600; Семейство: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGS06А, 600 х 600; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGS06А, 600 х 600; Тип: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGS06А, 600 х 600
Размеры - ADSK_Размер_Глубина: 600 mm; Объем: 0.0374034 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 600 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 12P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 6; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: H; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 3; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: Hyundai, HGS08А, 600 х 600, НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC:Hyundai, HGS08А, 600 х 600:844997
In: Этаж 01
Type - Material: DKC_Металл_Светлый, DKC_Металл_Серый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок воздушный AB, Hyundai, HGS08А, 600 х 600; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: Hyundai, HGS08А, 600 х 600; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_3: 3хх - воздушный АВ; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 8; 05_Производитель силовых аппаратов: H; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC
Type - Размеры - ADSK_Размер_Высота: 600 mm; ADSK_Размер_Ширина: 600 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: Hyundai, HGS08А, 600 х 600
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 3хх - воздушный АВ; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Марка: 147
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGS08А, 600 х 600; Семейство: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGS08А, 600 х 600; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGS08А, 600 х 600; Тип: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGS08А, 600 х 600
Размеры - ADSK_Размер_Глубина: 600 mm; Объем: 0.0374034 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 600 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 12P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 8; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: H; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 3; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: Hyundai, HGS10А, 600 х 600, НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC:Hyundai, HGS10А, 600 х 600:844998
In: Этаж 01
Type - Material: DKC_Металл_Светлый, DKC_Металл_Серый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок воздушный AB, Hyundai, HGS10А, 600 х 600; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: Hyundai, HGS10А, 600 х 600; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_3: 3хх - воздушный АВ; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 10; 05_Производитель силовых аппаратов: H; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC
Type - Размеры - ADSK_Размер_Высота: 600 mm; ADSK_Размер_Ширина: 600 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: Hyundai, HGS10А, 600 х 600
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 3хх - воздушный АВ; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 148
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGS10А, 600 х 600; Семейство: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGS10А, 600 х 600; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGS10А, 600 х 600; Тип: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGS10А, 600 х 600
Размеры - ADSK_Размер_Глубина: 600 mm; Объем: 0.0374034 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 600 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 12P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 10; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: H; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 3; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: Hyundai, HGS12А, 600 х 600, НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC:Hyundai, HGS12А, 600 х 600:844999
In: Этаж 01
Type - Material: DKC_Металл_Светлый, DKC_Металл_Серый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок воздушный AB, Hyundai, HGS12А, 600 х 600; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: Hyundai, HGS12А, 600 х 600; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_3: 3хх - воздушный АВ; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 12; 05_Производитель силовых аппаратов: H; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC
Type - Размеры - ADSK_Размер_Высота: 600 mm; ADSK_Размер_Ширина: 600 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: Hyundai, HGS12А, 600 х 600
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 3хх - воздушный АВ; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Марка: 149
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGS12А, 600 х 600; Семейство: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGS12А, 600 х 600; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGS12А, 600 х 600; Тип: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Hyundai, HGS12А, 600 х 600
Размеры - ADSK_Размер_Глубина: 600 mm; Объем: 0.0374034 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 600 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 12P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 12; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: H; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 3; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: Hyundai, HGS16А, 600 х 600, НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC:Hyundai, HGS16А, 600 х 600:845000
In: Этаж 01
Type - Material: DKC_Металл_Светлый, DKC_Металл_Серый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок воздушный AB, Hyundai, HGS16А, 600 х 600; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
