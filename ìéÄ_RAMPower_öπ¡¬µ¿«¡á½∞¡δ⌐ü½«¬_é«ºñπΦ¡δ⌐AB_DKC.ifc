Properties of the parts of a building model (IFC2X3), part 5 of 5

# IfcBuildingElementProxy: Siemens, 3WTI, 600 х 600, НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC:Siemens, 3WTI, 600 х 600:844777
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: Siemens, 3WTI, 600 х 600
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 3хх - воздушный АВ; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 134
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Siemens, 3WTI, 600 х 600; Семейство: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Siemens, 3WTI, 600 х 600; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Siemens, 3WTI, 600 х 600; Тип: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Siemens, 3WTI, 600 х 600
Размеры - ADSK_Размер_Глубина: 600 mm; Объем: 0.0374034 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 600 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 12P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 16; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: I; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 3; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: Siemens, 3WTII, 800 х 600, НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC:Siemens, 3WTII, 800 х 600:844778
In: Этаж 01
Type - Material: DKC_Металл_Светлый, DKC_Металл_Серый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок воздушный AB, Siemens, 3WTII, 800 х 600; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: Siemens, 3WTII, 800 х 600; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_3: 3хх - воздушный АВ; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 25; 05_Производитель силовых аппаратов: I; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC
Type - Размеры - ADSK_Размер_Высота: 600 mm; ADSK_Размер_Ширина: 800 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: Siemens, 3WTII, 800 х 600
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 3хх - воздушный АВ; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Марка: 135
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Siemens, 3WTII, 800 х 600; Семейство: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Siemens, 3WTII, 800 х 600; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Siemens, 3WTII, 800 х 600; Тип: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: Siemens, 3WTII, 800 х 600
Размеры - ADSK_Размер_Глубина: 600 mm; Объем: 0.0617923 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 600 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 12P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 25; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: I; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 3; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 8
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: ДКС, AD S1, 600 х 500, НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC:ДКС, AD S1, 600 х 500:843949
In: Этаж 01
Type - Material: DKC_Металл_Светлый, DKC_Металл_Серый
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Наименование: Функциональный блок воздушный AB, ДКС, AD S1, 600 х 500; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: ДКС, AD S1, 600 х 500; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 03_Номинальный ток: 16; 05_Производитель силовых аппаратов: Y; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_3: 3хх - воздушный АВ; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC
Type - Размеры - ADSK_Размер_Высота: 500 mm; ADSK_Размер_Ширина: 600 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: ДКС, AD S1, 600 х 500
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 3хх - воздушный АВ; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Рабочая плоскость: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 109
Прочее - Код типа: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: ДКС, AD S1, 600 х 500; Семейство: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: ДКС, AD S1, 600 х 500; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: ДКС, AD S1, 600 х 500; Тип: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: ДКС, AD S1, 600 х 500; Уровень спецификации: Уровень: Этаж 01
Размеры - ADSK_Размер_Глубина: 600 mm; Объем: 0.037254 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 600 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 10P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 16; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: Y; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 3; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Усредненный коэффициент спроса: 1; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: ДКС, AD S2, 600 х 600, НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC:ДКС, AD S2, 600 х 600:843954
In: Этаж 01
Type - Material: DKC_Металл_Светлый, DKC_Металл_Серый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок воздушный AB, ДКС, AD S2, 600 х 600; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: ДКС, AD S2, 600 х 600; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_3: 3хх - воздушный АВ; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 20; 05_Производитель силовых аппаратов: Y; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC
Type - Размеры - ADSK_Размер_Высота: 600 mm; ADSK_Размер_Ширина: 600 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: ДКС, AD S2, 600 х 600
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 3хх - воздушный АВ; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Марка: 110
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: ДКС, AD S2, 600 х 600; Семейство: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: ДКС, AD S2, 600 х 600; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: ДКС, AD S2, 600 х 600; Тип: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: ДКС, AD S2, 600 х 600
Размеры - ADSK_Размер_Глубина: 600 mm; Объем: 0.0374034 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 600 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 12P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 20; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: Y; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 3; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: ДКС, AD S4, 600 х 600, НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC:ДКС, AD S4, 600 х 600:843955
In: Этаж 01
Type - Material: DKC_Металл_Светлый, DKC_Металл_Серый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок воздушный AB, ДКС, AD S4, 600 х 600; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: ДКС, AD S4, 600 х 600; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_3: 3хх - воздушный АВ; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 25; 05_Производитель силовых аппаратов: Y; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC
Type - Размеры - ADSK_Размер_Высота: 600 mm; ADSK_Размер_Ширина: 600 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: ДКС, AD S4, 600 х 600
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 3хх - воздушный АВ; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 111
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: ДКС, AD S4, 600 х 600; Семейство: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: ДКС, AD S4, 600 х 600; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: ДКС, AD S4, 600 х 600; Тип: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: ДКС, AD S4, 600 х 600
Размеры - ADSK_Размер_Глубина: 600 mm; Объем: 0.0374034 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 600 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 12P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 25; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: Y; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 3; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: КЭАЗ, S1K, 600 х 500, НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC:КЭАЗ, S1K, 600 х 500:864329
In: Этаж 01
Type - Material: DKC_Металл_Светлый, DKC_Металл_Серый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок воздушный AB, КЭАЗ, S1K, 600 х 500; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: КЭАЗ, S1K, 600 х 500; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_3: 3хх - воздушный АВ; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 16; 05_Производитель силовых аппаратов: K; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC
Type - Размеры - ADSK_Размер_Высота: 500 mm; ADSK_Размер_Ширина: 600 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: КЭАЗ, S1K, 600 х 500
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 3хх - воздушный АВ; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 167
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: КЭАЗ, S1K, 600 х 500; Семейство: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: КЭАЗ, S1K, 600 х 500; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: КЭАЗ, S1K, 600 х 500; Тип: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: КЭАЗ, S1K, 600 х 500
Размеры - ADSK_Размер_Глубина: 600 mm; Объем: 0.037254 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 600 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 10P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 16; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: K; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 3; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: КЭАЗ, S2K, 600 х 600, НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC:КЭАЗ, S2K, 600 х 600:864330
In: Этаж 01
Type - Material: DKC_Металл_Светлый, DKC_Металл_Серый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок воздушный AB, КЭАЗ, S2K, 600 х 600; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: КЭАЗ, S2K, 600 х 600; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_3: 3хх - воздушный АВ; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 20; 05_Производитель силовых аппаратов: K; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC
Type - Размеры - ADSK_Размер_Высота: 600 mm; ADSK_Размер_Ширина: 600 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: КЭАЗ, S2K, 600 х 600
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 3хх - воздушный АВ; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 168
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: КЭАЗ, S2K, 600 х 600; Семейство: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: КЭАЗ, S2K, 600 х 600; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: КЭАЗ, S2K, 600 х 600; Тип: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: КЭАЗ, S2K, 600 х 600
Размеры - ADSK_Размер_Глубина: 600 mm; Объем: 0.0374034 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 600 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 12P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 20; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: K; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 3; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcBuildingElementProxy: КЭАЗ, S4K, 600 х 600, НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC:КЭАЗ, S4K, 600 х 600:864331
In: Этаж 01
Type - Material: DKC_Металл_Светлый, DKC_Металл_Серый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Металл_Светлый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Наименование: Функциональный блок воздушный AB, КЭАЗ, S4K, 600 х 600; ADSK_Обозначение: ГОСТ МЭК Р 61439.1&2; DKC_Соответствие нормативному документу: ГОСТ МЭК Р 61439.1&2
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/851/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: ramcube@dkc.ru; DKC_Программное обеспечение для конфигурирования URL: https://www.dkc.ru/ru/support/software/mnogofunktsionalnoe-programmnoe-obespechenie-ram-cube/; DKC_Сертификаты URL: https://www.dkc.ru/ru/support/certificates/; DKC_Тех. поддержка телефон: 8 (800) 250-52-63; URL: https://power.dkc.ru/ru/; Изготовитель: DKC; Имя типа: КЭАЗ, S4K, 600 х 600; Описание: «RAM power» — система, предназначенная для построения низковольтных комплектных устройств (НКУ) на токи до 6300 А в соответствии с новым стандартом ГОСТ P МЭК 61439. Отличительная особенность системы - огромный выбор готовых функциональных блоков для монтажа большинства серий автоматических выключателей, таких как 3VT, 3WL/3WT, Compact NS/NSX, Masterpact NW/NT, Tmax XT, T, Emax E. Организация внутреннего секционирования до степени 4b предотвращает распространение электрической дуги и обеспечивает безопасность обслуживающего персонала.
Type - Прочее - Категория: Электрооборудование; 02_Установка_A: A - вертикальный односторонний; 02_Установка_B: B - вертикальный двустронний; 02_Установка_C: C - горизонтальный односторонний; 02_Установка_D: D - горизонтальный двустронний; 06_Номер схемного решения_1 часть_0: 0xx - общесекционное устройство; 06_Номер схемного решения_1 часть_3: 3хх - воздушный АВ; 06_Номер схемного решения_1 часть_9: 9xx - Резервный АВ; 07_Способ установки_F: F - стационарный; 07_Способ установки_P: P - втычной; 07_Способ установки_W: W - выкатной; 09_Секционирование_2B: 2B; 09_Секционирование_2А: 2А; 09_Секционирование_3B: 3B; 09_Секционирование_3А: 3А; 09_Секционирование_4B: 4B; 09_Секционирование_4А: 4А; Глубина шкафа_400: 400 мм; Глубина шкафа_600: 600 мм; Глубина шкафа_800: 800 мм; 03_Номинальный ток: 25; 05_Производитель силовых аппаратов: K; Имя семейства: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC
Type - Размеры - ADSK_Размер_Высота: 600 mm; ADSK_Размер_Ширина: 600 mm
Type - Текст - ADSK_Масса: 0
Pset_BuildingElementProxyCommon - Reference: КЭАЗ, S4K, 600 х 600
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - 02_Установка: A - вертикальный односторонний; 06_Номер схемного решения_1 часть: 3хх - воздушный АВ; 06_Номер схемного решения_2 часть: 1; 07_Способ установки: F - стационарный; 08_Модификация базовой схемы: 0; 09_Секционирование: 2А
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Рабочая плоскость: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 169
Прочее - Уровень спецификации: Уровень: Этаж 01; Код типа: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: КЭАЗ, S4K, 600 х 600; Семейство: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: КЭАЗ, S4K, 600 х 600; Семейство и типоразмер: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: КЭАЗ, S4K, 600 х 600; Тип: НВО_RAMPower_ФункциональныйБлок_ВоздушныйAB_DKC: КЭАЗ, S4K, 600 х 600
Размеры - ADSK_Размер_Глубина: 600 mm; Объем: 0.0374034 m3
Стадии - Стадия возведения: Стадия 1
Строительство - Глубина шкафа: 600 мм
Текст - DKC_Артикул ФБ_01_Габарит в модулях: 12P; DKC_Артикул ФБ_02_Установка: A; DKC_Артикул ФБ_03_Номинальный ток: 25; DKC_Артикул ФБ_04_Количество полюсов выключателя: 3; DKC_Артикул ФБ_05_Производитель силовых аппаратов: K; DKC_Артикул ФБ_06_Номер схемного решения_1 часть: 3; DKC_Артикул ФБ_06_Номер схемного решения_2 часть: 01; DKC_Артикул ФБ_07_Способ установки: F; DKC_Артикул ФБ_08_Модификация базовой схемы: 0; DKC_Артикул ФБ_09_Секционирование: 2А; DKC_Артикул ФБ_10_Ширина: 6
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W
